# Repository manvalan/MuonScope (continued)

## KiCad design SchedaIMX6ULL-SD/prova-ddr/ProvaDDR.kicad_pcb (continued)

Schematic: cpu.kicad_sch

Parts:
C101, C104, C116, C119, C127: 22uF; C_0805_2012Metric
C102, C103, C105, C106, C107, C109, C110, C112, C113, C115, C131: 1uF; C_0603_1608Metric
C108, C111, C114: 10uF; C_0805_2012Metric
C117, C118, C120, C121, C122, C123, C124, C125, C126, C128, C129, C130: 100nF; C_0603_1608Metric
C132, C133: 18pF; C_0603_1608Metric
C134, C135: 12pF; C_0603_1608Metric
J6: Console UART1; PinHeader_1x03_P2.54mm_Vertical; MPN 2.54-1*3P; LCSC C49257
R101, R102, R106, R107: 10k; R_0603_1608Metric
R103, R104: 10k; R_0603_1608Metric; not fitted
R105: 4.7k; R_0603_1608Metric
SW1: RESET; SW-SMD_L3.9-W3.0-P4.45; MPN TS-1088-AR02016; LCSC C720477
SW2: ONOFF; SW-SMD_L3.9-W3.0-P4.45; MPN TS-1088-AR02016; LCSC C720477
U1: MCIMX6Y2CVM08AB; MAPBGA-289_14x14mm_Layout17x17_P0.8mm; MPN MCIMX6Y2CVM08AB
Y1: 24MHz; X322524MOB4SI_CRYSTAL-SMD_4P-L3.2-W2.5-BL; MPN X322524MOB4SI
Y2: 32.768kHz; FC-135R_L3.2-W1.5; MPN Q13FC13500004; LCSC C32346

Connections:
3V3: C119.1, C120.1, C121.1, C122.1, C123.1, C124.1, C125.1, C126.1, C131.1, R101.2, R103.2, R104.2, R106.1, R107.1, U1.C4 (NVCC_SD1), U1.E7 (NVCC_NAND), U1.E13 (NVCC_LCD), U1.F4 (NVCC_CSI), U1.F13 (NVCC_ENET), U1.H13 (NVCC_UART), U1.J13 (NVCC_GPIO), U1.L13 (VDDA_ADC_3P3), U1.M13 (ADC_VREFH), U1.N13 (VDD_HIGH_IN), U1.P12 (VDD_SNVS_IN); also elsewhere on the board
5V_SYS: U1.U12 (USB_OTG2_VBUS); also elsewhere on the board
/Alimentazione/POR_B: SW1.1, U1.P8 (POR_B); also elsewhere on the board
/Alimentazione/PWR_SRC_ST: R107.2, U1.M15 (GPIO1_IO09); also elsewhere on the board
/Bus MIKILAB/DAC61402_FAULT: U1.B17 (ENET2_RX_EN); also elsewhere on the board
/Bus MIKILAB/ECSPI1_SCLK: U1.D4 (CSI_DATA04); also elsewhere on the board
/Bus MIKILAB/ECSPI2_SCLK: U1.G17 (UART4_TX_DATA); also elsewhere on the board
/Bus MIKILAB/MAIN_HIT_N: U1.D9 (LCD_HSYNC); also elsewhere on the board
/Bus MIKILAB/MAIN_I2C_SCL: U1.F3 (CSI_HSYNC); also elsewhere on the board
/Bus MIKILAB/MAIN_I2C_SDA: U1.F2 (CSI_VSYNC); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_ADDR_0: U1.C6 (NAND_DATA04); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_ADDR_1: U1.B6 (NAND_DATA05); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_ADDR_2: U1.A6 (NAND_DATA06); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_ALERT_N: U1.B8 (LCD_ENABLE); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_CS_MASTER: U1.D3 (CSI_DATA05); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_MISO: U1.D1 (CSI_DATA07); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_MOSI: U1.D2 (CSI_DATA06); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_PREFIX_0: U1.E1 (CSI_DATA03); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_PREFIX_1: U1.B4 (NAND_ALE); also elsewhere on the board
/Bus MIKILAB/MAIN_SPI_PREFIX_2: U1.A8 (LCD_CLK); also elsewhere on the board
/Bus MIKILAB/PWR_SPI_DAC_CS: U1.H14 (UART2_RTS_B); also elsewhere on the board
/Bus MIKILAB/PWR_SPI_INA239A_CS: U1.G16 (UART4_RX_DATA); also elsewhere on the board
/Bus MIKILAB/PWR_SPI_INA239B_CS: U1.J15 (UART2_CTS_B); also elsewhere on the board
/Bus MIKILAB/PWR_SPI_MISO: U1.G13 (UART5_RX_DATA); also elsewhere on the board
/Bus MIKILAB/PWR_SPI_MOSI: U1.F17 (UART5_TX_DATA); also elsewhere on the board
/Bus MIKILAB/VBIAS_ENABLE: U1.E9 (LCD_RESET); also elsewhere on the board
/Bus MIKILAB/VREF_ENABLE: U1.C9 (LCD_VSYNC); also elsewhere on the board
/CPU/BOOT_CFG1_4: R103.1, U1.C10 (LCD_DATA04)
/CPU/BOOT_CFG1_6: R104.1, U1.A10 (LCD_DATA06)
/CPU/BOOT_MODE0: R102.1, U1.T10 (BOOT_MODE0)
/CPU/BOOT_MODE1: R101.1, U1.U10 (BOOT_MODE1)
/CPU/BT_DIS_N: U1.C16 (ENET2_RX_DATA1); also elsewhere on the board
/CPU/BT_HOST_WAKE: U1.K15 (UART1_CTS_B); also elsewhere on the board
/CPU/BT_UART_CTS: U1.D16 (ENET2_RX_ER); also elsewhere on the board
/CPU/BT_UART_RX: U1.A16 (ENET2_TX_DATA1); also elsewhere on the board
/CPU/BT_UART_TX: U1.B15 (ENET2_TX_EN); also elsewhere on the board
/CPU/BT_WAKE_HOST: U1.H15 (UART3_CTS_B); also elsewhere on the board
/CPU/DDR_A0: U1.L5 (DRAM_ADDR00); also elsewhere on the board
/CPU/DDR_A1: U1.H2 (DRAM_ADDR01); also elsewhere on the board
/CPU/DDR_A2: U1.K1 (DRAM_ADDR02); also elsewhere on the board
/CPU/DDR_A3: U1.M2 (DRAM_ADDR03); also elsewhere on the board
/CPU/DDR_A4: U1.K4 (DRAM_ADDR04); also elsewhere on the board
/CPU/DDR_A5: U1.L1 (DRAM_ADDR05); also elsewhere on the board
/CPU/DDR_A6: U1.G2 (DRAM_ADDR06); also elsewhere on the board
/CPU/DDR_A7: U1.H4 (DRAM_ADDR07); also elsewhere on the board
/CPU/DDR_A8: U1.J4 (DRAM_ADDR08); also elsewhere on the board
/CPU/DDR_A9: U1.L2 (DRAM_ADDR09); also elsewhere on the board
/CPU/DDR_A10: U1.M4 (DRAM_ADDR10); also elsewhere on the board
/CPU/DDR_A11: U1.K3 (DRAM_ADDR11); also elsewhere on the board
/CPU/DDR_A12: U1.L4 (DRAM_ADDR12); also elsewhere on the board
/CPU/DDR_A13: U1.H3 (DRAM_ADDR13); also elsewhere on the board
/CPU/DDR_A14: U1.G1 (DRAM_ADDR14); also elsewhere on the board
/CPU/DDR_A15: U1.K5 (DRAM_ADDR15); also elsewhere on the board
/CPU/DDR_BA0: U1.M1 (DRAM_SDBA0); also elsewhere on the board
/CPU/DDR_BA1: U1.H1 (DRAM_SDBA1); also elsewhere on the board
/CPU/DDR_BA2: U1.K2 (DRAM_SDBA2); also elsewhere on the board
/CPU/DDR_CAS_N: U1.J2 (DRAM_CAS_B); also elsewhere on the board
/CPU/DDR_CKE: U1.M3 (DRAM_SDCKE0); also elsewhere on the board
/CPU/DDR_CK_N: U1.P2 (DRAM_SDCLK0_N); also elsewhere on the board
/CPU/DDR_CK_P: U1.P1 (DRAM_SDCLK0_P); also elsewhere on the board
/CPU/DDR_CS_N: U1.N2 (DRAM_CS0_B); also elsewhere on the board
/CPU/DDR_DQ0: U1.T4 (DRAM_DATA00); also elsewhere on the board
/CPU/DDR_DQ1: U1.U6 (DRAM_DATA01); also elsewhere on the board
/CPU/DDR_DQ2: U1.T6 (DRAM_DATA02); also elsewhere on the board
/CPU/DDR_DQ3: U1.U7 (DRAM_DATA03); also elsewhere on the board
/CPU/DDR_DQ4: U1.U8 (DRAM_DATA04); also elsewhere on the board
/CPU/DDR_DQ5: U1.T8 (DRAM_DATA05); also elsewhere on the board
/CPU/DDR_DQ6: U1.T5 (DRAM_DATA06); also elsewhere on the board
/CPU/DDR_DQ7: U1.U4 (DRAM_DATA07); also elsewhere on the board
/CPU/DDR_DQ8: U1.U2 (DRAM_DATA08); also elsewhere on the board
/CPU/DDR_DQ9: U1.U3 (DRAM_DATA09); also elsewhere on the board
/CPU/DDR_DQ10: U1.U5 (DRAM_DATA10); also elsewhere on the board
/CPU/DDR_DQ11: U1.R4 (DRAM_DATA11); also elsewhere on the board
/CPU/DDR_DQ12: U1.P5 (DRAM_DATA12); also elsewhere on the board
/CPU/DDR_DQ13: U1.P3 (DRAM_DATA13); also elsewhere on the board
/CPU/DDR_DQ14: U1.R2 (DRAM_DATA14); also elsewhere on the board
/CPU/DDR_DQ15: U1.R1 (DRAM_DATA15); also elsewhere on the board
/CPU/DDR_LDM: U1.T7 (DRAM_DQM0); also elsewhere on the board
/CPU/DDR_LDQS_N: U1.P7 (DRAM_SDQS0_N); also elsewhere on the board
/CPU/DDR_LDQS_P: U1.P6 (DRAM_SDQS0_P); also elsewhere on the board
/CPU/DDR_ODT: U1.N1 (DRAM_ODT0); also elsewhere on the board
/CPU/DDR_RAS_N: U1.M5 (DRAM_RAS_B); also elsewhere on the board
/CPU/DDR_RESET_N: U1.G4 (DRAM_RESET); also elsewhere on the board
/CPU/DDR_UDM: U1.T3 (DRAM_DQM1); also elsewhere on the board
/CPU/DDR_UDQS_N: U1.T2 (DRAM_SDQS1_N); also elsewhere on the board
/CPU/DDR_UDQS_P: U1.T1 (DRAM_SDQS1_P); also elsewhere on the board
/CPU/DDR_VREF: U1.P4 (DRAM_VREF); also elsewhere on the board
/CPU/DDR_WE_N: U1.J1 (DRAM_SDWE_B); also elsewhere on the board
/CPU/GNSS_EXTINT: U1.J16 (UART2_RX_DATA); also elsewhere on the board
/CPU/GNSS_PPS: U1.J17 (UART2_TX_DATA); also elsewhere on the board
/CPU/GNSS_UART_RX: U1.H17 (UART3_TX_DATA); also elsewhere on the board
/CPU/GNSS_UART_TX: U1.H16 (UART3_RX_DATA); also elsewhere on the board
/CPU/I2C1_SCL: U1.L14 (GPIO1_IO02); also elsewhere on the board
/CPU/I2C1_SDA: U1.L17 (GPIO1_IO03); also elsewhere on the board
/CPU/JTAG_MOD: R105.1, U1.P15 (JTAG_MOD)
/CPU/NVCC_PLL: C111.1, C112.1, U1.P13 (NVCC_PLL)
/CPU/ONOFF: SW2.1, U1.R8 (ONOFF)
/CPU/PHY_MDC: U1.L16 (GPIO1_IO07); also elsewhere on the board
/CPU/PHY_MDIO: U1.K17 (GPIO1_IO06); also elsewhere on the board
/CPU/PHY_RST_N: U1.L15 (GPIO1_IO01); also elsewhere on the board
/CPU/QSPI_CS1_N: U1.A5 (NAND_DATA07); also elsewhere on the board
/CPU/QSPI_CS_N: U1.E6 (NAND_DQS); also elsewhere on the board
/CPU/QSPI_D0: U1.A3 (NAND_READY_B); also elsewhere on the board
/CPU/QSPI_D1: U1.C5 (NAND_CE0_B); also elsewhere on the board
/CPU/QSPI_D2: U1.B5 (NAND_CE1_B); also elsewhere on the board
/CPU/QSPI_D3: U1.A4 (NAND_CLE); also elsewhere on the board
/CPU/QSPI_SCLK_S: U1.D5 (NAND_WP_B); also elsewhere on the board
/CPU/RMII_CRSDV: U1.E16 (ENET1_RX_EN); also elsewhere on the board
/CPU/RMII_REFCLK: U1.F14 (ENET1_TX_CLK); also elsewhere on the board
/CPU/RMII_RXD0: U1.F16 (ENET1_RX_DATA0); also elsewhere on the board
/CPU/RMII_RXD1: U1.E17 (ENET1_RX_DATA1); also elsewhere on the board
/CPU/RMII_RXER: U1.D15 (ENET1_RX_ER); also elsewhere on the board
/CPU/RMII_TXD0: U1.E15 (ENET1_TX_DATA0); also elsewhere on the board
/CPU/RMII_TXD1: U1.E14 (ENET1_TX_DATA1); also elsewhere on the board
/CPU/RMII_TXEN: U1.F15 (ENET1_TX_EN); also elsewhere on the board
/CPU/RTC_XTALI: C134.1, U1.T11 (RTC_XTALI), Y2.1
/CPU/RTC_XTALO: C135.1, U1.U11 (RTC_XTALO), Y2.2
/CPU/SD1_CD_N: U1.J14 (UART1_RTS_B); also elsewhere on the board
/CPU/SD1_CLK_S: U1.C1 (SD1_CLK); also elsewhere on the board
/CPU/SD1_CMD: U1.C2 (SD1_CMD); also elsewhere on the board
/CPU/SD1_D0: U1.B3 (SD1_DATA0); also elsewhere on the board
/CPU/SD1_D1: U1.B2 (SD1_DATA1); also elsewhere on the board
/CPU/SD1_D2: U1.B1 (SD1_DATA2); also elsewhere on the board
/CPU/SD1_D3: U1.A2 (SD1_DATA3); also elsewhere on the board
/CPU/SD2_CLK_S: U1.D8 (NAND_RE_B); also elsewhere on the board
/CPU/SD2_CMD: U1.C8 (NAND_WE_B); also elsewhere on the board
/CPU/SD2_D0: U1.D7 (NAND_DATA00); also elsewhere on the board
/CPU/SD2_D1: U1.B7 (NAND_DATA01); also elsewhere on the board
/CPU/SD2_D2: U1.A7 (NAND_DATA02); also elsewhere on the board
/CPU/SD2_D3: U1.D6 (NAND_DATA03); also elsewhere on the board
/CPU/SOC_DDR_ZQ: U1.N4 (DRAM_ZQPAD); also elsewhere on the board
/CPU/UART1_RX: J6.2, U1.K16 (UART1_RX_DATA)
/CPU/UART1_TX: J6.1, U1.K14 (UART1_TX_DATA)
/CPU/USB1_DM: U1.T15 (USB_OTG1_DN); also elsewhere on the board
/CPU/USB1_DP: U1.U15 (USB_OTG1_DP); also elsewhere on the board
/CPU/USB2_DM: U1.T13 (USB_OTG2_DN); also elsewhere on the board
/CPU/USB2_DP: U1.U13 (USB_OTG2_DP); also elsewhere on the board
/CPU/USB2_OC_N: R106.2, U1.N17 (GPIO1_IO08); also elsewhere on the board
/CPU/USB2_VBUS_EN: U1.M17 (GPIO1_IO05); also elsewhere on the board
/CPU/VDD_ARM_CAP: C101.1, C102.1, C103.1, U1.G9 (VDD_ARM_CAP), U1.G10 (VDD_ARM_CAP), U1.G11 (VDD_ARM_CAP), U1.H11 (VDD_ARM_CAP)
/CPU/VDD_HIGH_CAP: C108.1, C109.1, C110.1, U1.N6 (NVCC_DRAM_2P5), U1.R14 (VDD_HIGH_CAP), U1.R15 (VDD_HIGH_CAP)
/CPU/VDD_SNVS_CAP: C113.1, U1.N12 (VDD_SNVS_CAP)
/CPU/VDD_SOC_CAP: C104.1, C105.1, C106.1, C107.1, U1.G8 (VDD_SOC_CAP), U1.H8 (VDD_SOC_CAP), U1.J8 (VDD_SOC_CAP), U1.J11 (VDD_SOC_CAP), U1.K8 (VDD_SOC_CAP), U1.K11 (VDD_SOC_CAP), U1.L8 (VDD_SOC_CAP), U1.L9 (VDD_SOC_CAP), U1.L10 (VDD_SOC_CAP), U1.L11 (VDD_SOC_CAP)
/CPU/VDD_USB_CAP: C114.1, C115.1, U1.R12 (VDD_USB_CAP)
/CPU/WL_DIS_N: U1.C17 (ENET2_RX_DATA0); also elsewhere on the board
/CPU/WL_WAKE_HOST: U1.G14 (UART3_RTS_B); also elsewhere on the board
/CPU/XTALI: C132.1, U1.T16 (XTALI), Y1.1 (OSC1)
/CPU/XTALO: C133.1, U1.T17 (XTALO), Y1.3 (OSC2)
GND_D: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, J6.3, R102.2, R105.2, SW1.2, SW2.2, U1.A1 (VSS), U1.A17 (VSS), U1.C3 (VSS), U1.C7 (VSS), U1.C11 (VSS), U1.C15 (VSS), U1.E8 (VSS), U1.E11 (VSS), U1.F6 (VSS), U1.F7 (VSS), U1.F8 (VSS), U1.F9 (VSS), U1.F10 (VSS), U1.F11 (VSS), U1.F12 (VSS), U1.G3 (VSS), U1.G5 (VSS), U1.G7 (VSS), U1.G12 (VSS), U1.G15 (VSS), U1.H7 (VSS), U1.H12 (VSS), U1.J5 (VSS), U1.J7 (VSS), U1.J12 (VSS), U1.K7 (VSS), U1.K12 (VSS), U1.L3 (VSS), U1.L7 (VSS), U1.L12 (VSS), U1.M7 (VSS), U1.M8 (VSS), U1.M9 (VSS), U1.M10 (VSS), U1.M11 (VSS), U1.M12 (NGND_KEL0), U1.N3 (VSS), U1.N5 (VSS), U1.N7 (TEST_MODE), U1.R3 (VSS), U1.R5 (VSS), U1.R7 (VSS), U1.R11 (VSS), U1.R16 (VSS), U1.R17 (VSS), U1.T14 (VSS), U1.U1 (VSS), U1.U14 (VSS), U1.U17 (VSS), Y1.2 (GND), Y1.4 (GND); also elsewhere on the board
V1P4: C116.1, C117.1, C118.1, U1.H9 (VDD_SOC_IN), U1.H10 (VDD_SOC_IN), U1.J9 (VDD_SOC_IN), U1.J10 (VDD_SOC_IN), U1.K9 (VDD_SOC_IN), U1.K10 (VDD_SOC_IN); also elsewhere on the board
V1P35: C127.1, C128.1, C129.1, C130.1, U1.G6 (NVCC_DRAM), U1.H6 (NVCC_DRAM), U1.J6 (NVCC_DRAM), U1.K6 (NVCC_DRAM), U1.L6 (NVCC_DRAM), U1.M6 (NVCC_DRAM); also elsewhere on the board
VBUS1: U1.T12 (USB_OTG1_VBUS); also elsewhere on the board

Notes on the sheet:
U1 NXP MCIMX6Y2CVM08AB (i.MX 6ULL full feature, 792 MHz, -40..105 C, MAPBGA-289 14x14 mm passo 0.8). Sfere: IMX6ULLCEC Rev 1.2 tabelle 90/91, confrontate con la netlist di una scheda KiCad aperta: 289/289.
Boot: BOOT_MODE[1:0]=10 (boot interno) e BOOT_CFG tutti bassi con i pull-down interni da 100k (tabella 78) = QSPI, come SW601 tutto OFF sulla EVK NXP. Pull-up DNP su LCD_DATA04 e LCD_DATA06 (microSD). Se QSPI e' vuota il ROM va in download seriale su USB_OTG1.
Assegnazione: ECSPI2=BUS_POWER, ECSPI1=MAIN, I2C2=bus MIKILAB, I2C1=EEPROM MAC, UART1=console, UART3=GNSS, UART8=BT, GPT1 CAPTURE1=PPS (UART2_TX), CAPTURE2=EXTINT (UART2_RX). Elenco completo in docs/pinmap-imx6ull.md.
VDD_ARM_CAP / VDD_SOC_CAP: uscite LDO interni, solo condensatori
VDD_HIGH_CAP (a NVCC_DRAM_2P5), NVCC_PLL, VDD_SNVS_CAP, VDD_USB_CAP
VDD_SOC_IN 1.4 V
VDD_HIGH_IN e NVCC 3.3 V: un 100 nF per dominio (CSI, ENET, GPIO, LCD, NAND, SD1, UART)
NVCC_DRAM 1.35 V (lato SoC)
VDD_SNVS_IN
Carico 24 MHz (CL da verificare sul quarzo YXC)
Carico RTC: circa 2xCL meno parassite (datasheet, tabella 3)
Boot: BOOT_MODE=10; BOOT_CFG1[4] e [6] DNP finche' lo strap QSPI non e' confermato sulla fuse map; JTAG_MOD a GND con 4.7k (tabella 3)
Pull-up open drain USB2_OC_N, PWR_SRC_ST

Board: 4 copper layers, 233 parts (39 on the bottom side), 223 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: MountingHole_2.2mm_M2

## KiCad design SchedaH616/progetto-kicad/SchedaRK3568.kicad_pcb

File SchedaH616/README.md:

# Scheda RK3568 (cartella SchedaH616)

Scheda Linux basata su **Rockchip RK3568** per il progetto MuonScope, sul **bus MIKILAB**. Nasce come SchedaH616: la cartella
mantiene il vecchio nome, il progetto KiCad è `progetto-kicad/SchedaRK3568.kicad_pro`.

- SoC **RK3568** (FCBGA636L 19x19 mm, passo 0.65, LCSC C2938930), PMIC **RK809-5** + **TCS4525** per VDD_CPU, come Rockchip RK3568 AIoT REF e Radxa ROCK 3A
- **DDR4 2 GB** x16 Samsung K4AAG165WA-BCWE (un chip, point-to-point, niente VTT, VPP 2.5 V da AP2112K-2.5)
- eMMC FORESEE FEMDNN064G-C9A61 (64 GB, HS400) su EMMC 8 bit a 1.8 V (AP2112K-1.8), microSD su SDMMC0
- Ethernet Gigabit RTL8211F su GMAC0 RGMII + HR911130C con EEPROM MAC 25AA02E48, Wi-Fi/BT AP6256 su SDMMC2 + UART8, GNSS NEO-M9N (PPS e time mark su GPIO)
- Alimentazione: 12 V dal BUS_POWER direttamente al buck TPS56637 (niente eFuse), jack 5 V, due TPS2121 in cascata (bus > jack > USB-C),
  USB-C con FUSB302B (anche porta OTG per il flash con rkdeveloptool), VCC3V3_SYS dal TPS563201; porta USB-C host con TPS2553
- Bus MIKILAB: BUS_POWER 30 pin su SPI3, MAIN 28 pin REV5.1 su SPI2 (HIT# sul pin 28), linee lente su GPIO diretti (niente espansore)
- Tasti RESET (rete RESETn della PMIC) e RECOVERY (SARADC_VIN0), console UART2 su J301

## Contenuto

| Percorso | Cosa |
|---|---|
| `progetto-kicad/` | Progetto KiCad 10 `SchedaRK3568.kicad_pro`, libreria simboli `Scheda.kicad_sym`, footprint `Scheda.pretty`, modelli 3D `Scheda.3dshapes` |
| `schema-rk3568.pdf` | Schema completo esportato |
| `pcb-placement-rk3568.pdf` / `.png` | Placement del PCB 70 x 90 mm, top e bottom |
| `generatori/` | Script Python che generano fogli, footprint del SoC e PCB; `build.sh` rifà lo schema (ERC, PDF, mappa dei pin), `build_pcb.sh` il PCB |
| `docs/scelte-progetto.md` | Fonti, rail, assegnazione GPIO, DDR4, incongruenze con le note, **punti aperti** |
| `docs/pinmap-rk3568.md` | Mappa RK3568 sfera per sfera con la net di ogni sfera |
| `docs/pcb-placement.md` | Scheda, regole, dove sta ogni componente, esito DRC |

Per rigenerare servono python3, KiCad 10 (Linux o macOS; i percorsi delle librerie standard sono in `generatori/kilib.py`) e la libreria
personale [MIKILAB](https://github.com/manvalan/mikilab-kicad-library) (variabile `MIKILAB`, o clonata in `~/Develop/mikilab-kicad-library`),
da cui vengono simboli e footprint dei componenti specifici; cosa resta nella libreria di progetto `Scheda` e perché è in `docs/scelte-progetto.md`:

```bash
sh SchedaH616/generatori/build.sh
sh SchedaH616/generatori/build_pcb.sh
```

## Fogli dello schema

1. Radice
2. **CPU**: RK3568 in 9 unità, 24 MHz, RESET/RECOVERY, UART2, disaccoppiamento, interfaccia bus (serie, pull-up, ESD)
3. **Bus MIKILAB**: J1 BUS_POWER 30 pin, J2 MAIN 28 pin
4. **Alimentazione**: TPS56637, jack con TPS2121 U108, USB-C con FUSB302B, TPS2121 U103, SY6280AAC
5. **PMIC**: RK809-5, TCS4525, TPS563201, AP2112K-1.8, AP2112K-2.5
6. **Memorie**: DDR4, eMMC, microSD
7. **Rete**: RTL8211F, HR911130C, 25AA02E48
8. **Radio**: AP6256 + U.FL
9. **GNSS**: NEO-M9N, PPS OUT e STROBE IN su SMA, CR1220 sul V_BCKP
10. **USB host**: TPS2553 + USB-C solo host

## Stato

- Schema completo, **ERC a 0 violazioni** (KiCad 10.0.7), nessuna net con un solo pin
- Ball map RK3568 dal pinout ufficiale Rockchip, verificata sul datasheet V1.2 (636/636); DDR4 confrontata con il reference Rockchip AIoT
- **PCB**: 70 x 90 mm, 6 strati, solo placement, tutto sul top tranne il disaccoppiamento sotto SoC e DDR4; dettagli ed esito del DRC in `docs/pcb-placement.md`

## Punti aperti principali

L'elenco completo è in `docs/scelte-progetto.md`.

- TPS563201 (3 A) al limite per VCC3V3_SYS, che ora alimenta anche i buck dell'RK809-5
- DDR4 a 16 bit sul canale A: da confermare con il template Rockchip a 16 bit e con il loader
- RGMII a 3.3 V (Rockchip consiglia 1.8 V), quarzo 24 MHz e induttore del TCS4525 da confermare

Schematic: bus-mikilab.kicad_sch

Parts:
J1: BUS_POWER_MIKILAB; FPC-SMD_FH12-30S-0.5SH-55
J2: BUS_MIKILAB_MAIN; FPC-SMD_28P-P0.50_FPC-05F-28PH20
R1, R2, R3, R4: 0R; R_0603_1608Metric

Connections:
/Bus MIKILAB/BUS_1V25_REF: J1.6, J2.6
/Bus MIKILAB/BUS_2V5_REF: J1.5, J2.5
/Bus MIKILAB/BUS_3V3: J1.9, J1.29, J2.3
/Bus MIKILAB/BUS_5V: J1.8, J2.2
/Bus MIKILAB/BUS_VBIAS_1: J1.2, J2.8
/Bus MIKILAB/BUS_VBIAS_2: J1.3, J2.9
/Bus MIKILAB/SPI_ID_0: J2.25, R1.1
/Bus MIKILAB/SPI_ID_1: J2.26, R2.1
/Bus MIKILAB/SPI_ID_2: J2.27, R3.1
/DAC61402_FAULT: J1.20; also elsewhere on the board
/MAIN_HIT_N: J2.28; also elsewhere on the board
/MAIN_I2C_SCL: J2.15; also elsewhere on the board
/MAIN_I2C_SDA: J2.14; also elsewhere on the board
/MAIN_SPI_ADDR_0: J2.18; also elsewhere on the board
/MAIN_SPI_ADDR_1: J2.19; also elsewhere on the board
/MAIN_SPI_ADDR_2: J2.20; also elsewhere on the board
/MAIN_SPI_ALERT_N: J2.24; also elsewhere on the board
/MAIN_SPI_CS_MASTER: J2.17; also elsewhere on the board
/MAIN_SPI_MISO: J2.13; also elsewhere on the board
/MAIN_SPI_MOSI: J2.12; also elsewhere on the board
/MAIN_SPI_PREFIX_0: J2.21; also elsewhere on the board
/MAIN_SPI_PREFIX_1: J2.22; also elsewhere on the board
/MAIN_SPI_PREFIX_2: J2.23; also elsewhere on the board
/MAIN_SPI_SCLK: J2.11; also elsewhere on the board
/PWR_SPI_DAC_CS: J1.17; also elsewhere on the board
/PWR_SPI_INA239A_CS: J1.15; also elsewhere on the board
/PWR_SPI_INA239B_CS: J1.16; also elsewhere on the board
/PWR_SPI_MISO: J1.13; also elsewhere on the board
/PWR_SPI_MOSI: J1.12; also elsewhere on the board
/PWR_SPI_SCLK: J1.11; also elsewhere on the board
/VBIAS_ENABLE: J1.19; also elsewhere on the board
/VIN_SYS: J1.24, J1.25, J1.26; also elsewhere on the board
/VREF_ENABLE: J1.18; also elsewhere on the board
GND_A: J1.1, J1.4, J1.7, J2.7, R4.1
GND_D: J1.10, J1.14, J1.21, J1.22, J1.23, J1.27, J1.28, J1.30, J1.31, J1.32, J2.1, J2.4, J2.10, J2.16, J2.29, J2.30, R1.2, R2.2, R3.2, R4.2; also elsewhere on the board

Notes on the sheet:
J1 BUS_POWER 30 pin (Hirose FH12-30S): pin 1-22 come J3 del modulo Power, 24-26 VIN_SYS 12 V, 29 secondo 3V3. Rail BUS_* passanti verso J2, non collegati ai rail della scheda.
VIN_SYS -> buck TPS56637 12->5 V (foglio Alimentazione), senza eFuse. BUS_5V va solo a J2 pin 2.
J2 MAIN 28 pin secondo BPS-MIKILAB-2026-REV5.1 (pin 28 = HIT#) (XUNPU FPC-05F-28PH20, LCSC C2856807; simbolo e footprint dalla libreria MIKILAB).
Sul foglio CPU: BUS_POWER su SPI3_M1 e MAIN su SPI2_M1 (due controller separati) con 33R serie, 100R su ADDR/PREFIX, pull-up 4.7k su ALERT#/HIT#, 2.2k su I2C, 10k sui CS, ESD TPD4E05U06.
R4 0R: ponte GND_A-GND_D, DNP di default (sul modulo Power GND_A e GND_D sono gia la stessa net). R1-R3: ID iniziale 000 (scheda = J_OUT, testa della catena).

Schematic: alimentazione.kicad_sch

Parts:
C101, C102: 10uF/25V; C_1206_3216Metric
C103, C109, C110, C132, C136: 100nF; C_0603_1608Metric
C104, C105, C127, C128: 22uF/10V; C_1206_3216Metric
C106, C113: 22uF/10V; C_0805_2012Metric
C107: 4.7uF/10V; C_0603_1608Metric
C108: 1uF; C_0603_1608Metric
C111, C112, C114, C133, C134: 1uF/10V; C_0603_1608Metric
C115, C135: 10uF/10V; C_0805_2012Metric
C125: 100nF/50V; C_0603_1608Metric
C126: 100pF; C_0603_1608Metric
D101, D102: SMF5.0A; D_SMF
J103: DC-005-5A-2.0; BarrelJack_Horizontal
J104: TYPE-C-31-M-12; USB-C_SMD-TYPE-C-31-M-12_1
L101: 3.3uH/8A; L_Coilcraft_XAL6030-XXX; MPN XAL6030-332
R101: 169k 1%; R_0603_1608Metric
R102: 36.1k 1%; R_0603_1608Metric
R103: 73.2k 1%; R_0603_1608Metric
R104, R106, R108, R110, R122, R124, R126, R129: 10k 1%; R_0603_1608Metric
R105, R121: 32.4k 1%; R_0603_1608Metric
R107, R109, R123, R125: 46.4k 1%; R_0603_1608Metric
R111, R127: 22.1k 1%; R_0603_1608Metric
R112: 6.8k 1%; R_0603_1608Metric
R113, R115, R128: 100k; R_0603_1608Metric
R114: 10k; R_0603_1608Metric; not fitted
R116: 20k; R_0603_1608Metric
R130: 15k 1%; R_0603_1608Metric
TP101: MUX2_ST; TestPoint_Pad_D1.0mm
U101: TPS56637RPAR; VQFN-HR-10_L3.0-W3.0_RPA; MPN TPS56637RPAR
U103: TPS2121RUXR; IC_TPS2121RUXR
U104: FUSB302BMPX; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm
U105: SY6280AAC; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL
U107: TPD2EUSB30ADRTR; Texas_DRT-3; MPN TPD2EUSB30ADRTR
U108: TPS2121RUXR; IC_TPS2121RUXR; MPN TPS2121RUXR

Connections:
/5V_SYS: C113.1, C114.1, U103.1 (OUT), U103.1_1 (OUT), U103.8 (OUT), U103.8_1 (OUT); also elsewhere on the board
/Alimentazione/5V_BUCK: C104.1, C105.1, C127.1, C128.1, C133.1, L101.2, R103.1, R115.1, R116.1, R121.1, R123.1, U108.7 (IN1), U108.7_1 (IN1)
/Alimentazione/5V_EXT: C111.1, C115.1, C135.1, R105.1, R107.1, R128.1, U103.7 (IN1), U103.7_1 (IN1), U105.5 (IN), U108.1 (OUT), U108.1_1 (OUT), U108.8 (OUT), U108.8_1 (OUT)
/Alimentazione/5V_JACK: C106.1, C134.1, D101.1 (A1), J103.1, R125.1, U108.2 (IN2), U108.2_1 (IN2)
/Alimentazione/BUCK_BST: C103.1, U101.7 (BOOT)
/Alimentazione/BUCK_EN: R101.2, R102.1, U101.1 (EN)
/Alimentazione/BUCK_FB: C126.2, R103.2, R104.1, U101.2 (FB)
/Alimentazione/BUCK_FF: C126.1, R116.2
/Alimentazione/BUCK_MODE: R114.1, U101.10 (MODE)
/Alimentazione/BUCK_PG: R115.2, U101.4 (PG)
/Alimentazione/BUCK_SW: C103.2, L101.1, U101.6 (SW)
/Alimentazione/MUX2_ILM: R127.1, U108.10 (ILIM)
/Alimentazione/MUX2_OV1: R123.2, R124.1, U108.5 (OV1)
/Alimentazione/MUX2_OV2: R125.2, R126.1, U108.4 (OV2)
/Alimentazione/MUX2_PR1: R121.2, R122.1, U108.6 (PR1)
/Alimentazione/MUX2_SS: C132.1, U108.11 (SS)
/Alimentazione/MUX2_ST: R128.2, TP101.1, U108.9 (ST)
/Alimentazione/MUX_ILM: R111.1, U103.10 (ILIM)
/Alimentazione/MUX_OV1: R107.2, R108.1, U103.5 (OV1)
/Alimentazione/MUX_OV2: R109.2, R110.1, U103.4 (OV2)
/Alimentazione/MUX_PR1: R105.2, R106.1, U103.6 (PR1)
/Alimentazione/MUX_SS: C110.1, U103.11 (SS)
/Alimentazione/SRC_ISET: R112.1, U105.3 (ISET)
/Alimentazione/USBC_CC1: J104.A5 (CC1), U104.10 (CC1), U104.11 (CC1), U107.1 (D+)
/Alimentazione/USBC_CC2: J104.B5 (CC2), U104.1 (CC2), U104.14 (CC2), U107.2 (D-)
/Alimentazione/VBUS: C107.1, C112.1, D102.1 (A1), J104.A4B9 (VBUS), J104.B4A9 (VBUS), R109.1, R129.1, U103.2 (IN2), U103.2_1 (IN2), U104.2 (VBUS), U105.1 (OUT)
/I2C1_SCL: U104.6 (SCL); also elsewhere on the board
/I2C1_SDA: U104.7 (SDA); also elsewhere on the board
/OTG_VBUSDET: C136.1, R129.2, R130.1; also elsewhere on the board
/PD_INT_N: U104.5 (INT_N); also elsewhere on the board
/PWR_SRC_ST: U103.9 (ST); also elsewhere on the board
/USB0_DM: J104.A7 (DN1), J104.B7 (DN2); also elsewhere on the board
/USB0_DP: J104.A6 (DP1), J104.B6 (DP2); also elsewhere on the board
/VBUS_SRC_EN: R113.1, U105.4 (EN); also elsewhere on the board
/VCC3V3_SYS: C108.1, C109.1, U104.3 (VDD), U104.4 (VDD); also elsewhere on the board
/VIN_SYS: C101.1, C102.1, C125.1, R101.1, U101.8 (VIN); also elsewhere on the board
GND_D: C101.2, C102.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C125.2, C127.2, C128.2, C132.2, C133.2, C134.2, C135.2, C136.2, D101.2 (A2), D102.2 (A2), J103.2, J103.3, J104.1 (EH), J104.2 (EH), J104.3 (EH), J104.4 (EH), J104.A1B12 (GND), J104.B1A12 (GND), R102.2, R104.2, R106.2, R108.2, R110.2, R111.2, R112.2, R113.2, R114.2, R122.2, R124.2, R126.2, R127.2, R130.2, U101.3 (AGND), U101.9 (PGND), U103.3 (CP2), U103.12 (GND), U104.8 (GND), U104.9 (GND), U104.15 (GND), U105.2 (GND), U107.3 (GND), U108.3 (CP2), U108.12 (GND); also elsewhere on the board

Notes on the sheet:
1) VIN_SYS 12 V dal BUS_POWER (pin 24-26) -> buck TPS56637 12 -> 5 V / 6 A -> 5V_BUCK -> TPS2121 U108 (IN1, priorita). Niente eFuse e niente fusibile.
TPS56637 (tabella 4 del datasheet, Vout 5 V): Vfb 0.6 V, R103/R104 73.2k/10k = 4.99 V, L 3.3 uH, Cout 4x22 uF, feed-forward R116 20k + C126 100 pF.
EN: 169k/36.1k (schema tipico TI). MODE libero = FCCM (R114 DNP): frequenza fissa, ripple basso vicino al GNSS. Il jack e' separato dal TPS2121 U108, niente corrente inversa nel buck.
Senza eFuse il buck vede direttamente il BUS_POWER: niente limite di corrente, UVLO/OVLO e blocco inverso sui 12 V (protezione a carico del modulo Power).
2) Jack DC 5 V (DC-005-5A-2.0) su 5V_JACK, TVS D101, nessun fusibile. TPS2121 U108: IN1 = 5V_BUCK (bus 12 V) con priorita, IN2 = jack. Uscita 5V_EXT -> IN1 di U103.
U108 (datasheet TPS2121 SLVSEA3F): PR1 = 1.06 V x (32.4k+10k)/10k = 4.49 V -> sotto passa al jack; CP2 a GND = priorita fissa su IN1; OV 5.98 V; ILM 22.1k = 4-5 A; ST (basso = uscita dal jack, IN2) con 100k e test point TP101.
Priorita: bus 12 V (buck) > jack > USB-C. Il bus e' l'alimentazione di esercizio, il jack serve al banco, l'USB-C e' l'ultima risorsa (1.5-3 A).
3) USB-C (HRO TYPE-C-31-M-12): solo USB 2.0, FUSB302B per CC/PD, TVS SMF5.0A su VBUS (nessun fusibile), ESD TPD2EUSB30A su CC1/CC2
USB3_OTG0_VBUSDET (M24): VBUS x 15k/(10k+15k) = 3.0 V con 100 nF (Hardware Design Guide RK3568: 2.7-3.3 V, tip. 3.0 V). Serve al flash con rkdeveloptool (modo device).
FUSB302B (0x22): VDD da VCC3V3_SYS, I2C1 dell'RK3568 (GPIO0_B3/B4, PMUIO2 3.3 V) con pull-up 2.2k a VCC3V3_PMU e INT_N 10k a VCC_3V3 sul foglio CPU.
4) Power mux TPS2121 U103: IN1 5V_EXT (uscita di U108: bus o jack) con priorita, IN2 VBUS USB-C. Uscita 5V_SYS verso TPS563201 (VCC3V3_SYS), TCS4525 (VDD_CPU) e TPS2553
PR1: IN1 sotto 4.49 V -> passa a IN2. OV1/OV2: canale escluso sopra 5.98 V. CP2 a GND (modo VREF). ILM 22.1k -> 4-5 A. SS 100 nF.
5) SY6280AAC: VBUS in uscita verso una periferica (source, ~1 A). Ingresso da 5V_EXT: si accende solo con jack o VIN_SYS presenti
Ilim = 6800 / R112 = 1 A. R113: uscita spenta finche Linux non abilita VBUS_SRC_EN (GPIO0_A5, comandato da tcpm).

Schematic: pmic.kicad_sch

Parts:
C201: 22uF/10V; C_0603_1608Metric
C202, C203, C204, C209, C211, C235: 10uF/10V; C_0603_1608Metric
C205, C206, C207, C208, C210, C225, C226, C227, C229, C230, C231, C232, C233, C234, C236, C237, C238, C239, C248: 1uF; C_0603_1608Metric
C212, C213, C215, C216, C218, C220, C221, C223, C224, C249, C250, C251: 22uF; C_0603_1608Metric
C214, C217, C222, C242, C243, C244, C254, C255, C263, C264: 100nF; C_0603_1608Metric
C219: 10uF; C_0603_1608Metric
C228, C261, C262: 4.7uF; C_0603_1608Metric
C240, C241: 22pF; C_0603_1608Metric
C245, C246, C256, C257: 22uF/10V; C_0805_2012Metric
C247: 100nF; C_0603_1608Metric; not fitted
C252: 22uF; C_0603_1608Metric; not fitted
C253: 10uF/16V; C_0805_2012Metric
C258, C259, C260: 1uF/10V; C_0603_1608Metric
L201, L202, L203, L204, L205: 0.47uH/4A; L_1008_2520Metric; MPN TFM252012ALMA-R47MTAA
L206: 0.33uH/9A; L_Coilcraft_XAL4020-XXX; MPN XAL4020-331
L207: 2.2uH/4A; L_Coilcraft_XAL4020-XXX; MPN XAL4020-222
R201, R204, R209: 0R; R_0603_1608Metric
R202: 62k 1%; R_0603_1608Metric
R203: 120k 1%; R_0603_1608Metric
R205: DNP; R_0603_1608Metric; not fitted
R206, R207: 22R; R_0603_1608Metric
R208, R210: 10k; R_0603_1608Metric
R211, R215: 100k; R_0603_1608Metric
R212: 22k; R_0603_1608Metric
R213: 51k; R_0603_1608Metric
R214: 100R; R_0603_1608Metric
R216: 33.2k 1%; R_0603_1608Metric
R217: 10k 1%; R_0603_1608Metric
TP201: VCC_1V8; TestPoint_Pad_D1.0mm
TP202: PWRON; TestPoint_Pad_D1.0mm
U201: RK809-5; QFN-68_L7.0-W7.0-P0.35-BL-EP5.5; MPN RK809-5; LCSC C2939628
U202: TCS4525_WT; TCS4525_WLCSP-20_1.6x2.0mm_P0.4mm; MPN TCS4525_WT
U203: TPS563201DDCR; TPS563201DDCR_SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; MPN TPS563201DDCR
U204: AP2112K-1.8TRG1; SOT-25_L3.0-W1.6-P0.95-LS2.8-BL; MPN AP2112K-1.8TRG1; LCSC C176944
U205: AP2112K-2.5TRG1; SOT-23-5; MPN AP2112K-2.5TRG1
Y201: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm; MPN Q13FC1350000400

Connections:
/5V_SYS: C245.1, C246.1, C253.1, C254.1, R211.1, R215.1, U202.D1 (AVIN), U202.D2 (PVIN), U202.E1 (PVIN), U202.E2 (PVIN), U203.3 (VIN); also elsewhere on the board
/PMIC/PERI_BST: C255.1, U203.6 (VBST)
/PMIC/PERI_EN: R215.2, U203.5 (EN)
/PMIC/PERI_FB: R216.2, R217.1, U203.4 (VFB)
/PMIC/PERI_SW: C255.2, L207.1, U203.2 (SW)
/PMIC/TCS_EN: C247.1, R213.2, U202.A2 (EN)
/PMIC/TCS_SW: L206.1, U202.D3 (SW), U202.D4 (SW), U202.E3 (SW), U202.E4 (SW)
/PMIC/VCC_1V8: C223.1, C224.1, L205.2, R204.1, TP201.1
/VCC1V8_EMMC: C259.1, U204.5 (VOUT); also elsewhere on the board
/VCC2V5_DDR: C261.1, C262.1, C263.1, C264.1, U205.5 (VOUT); also elsewhere on the board
/VCC3V3_PMU: C230.1, R208.1, R210.1, R213.1, U201.31 (LDO6), U204.3 (EN), U205.3 (EN); also elsewhere on the board
/VCC3V3_SD: C234.1, U201.58 (SWOUT2); also elsewhere on the board
/VCC3V3_SYS: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C210.1, C239.1, C256.1, C257.1, C258.1, C260.1, L207.2, R201.1, R216.1, U201.4 (VCC7), U201.10 (VCC2), U201.11 (VCC1), U201.22 (VCC5), U201.24 (VCC3), U201.30 (VCC6), U201.45 (VCC_RTC), U201.54 (VCC9), U201.57 (VCC8), U201.66 (VCC4), U204.1 (VIN), U205.1 (VIN); also elsewhere on the board
/VCCA1V8_PMU: C232.1, U201.5 (LDO8); also elsewhere on the board
/VCCA_1V8: C231.1, U201.3 (LDO7); also elsewhere on the board
/VCCIO_SD: C229.1, U201.29 (LDO5); also elsewhere on the board
/VCC_3V3: C235.1, U201.55 (SWOUT1); also elsewhere on the board
/VCC_DDR: C218.1, C219.1, L203.2, R202.1, U201.26 (VBUCK3); also elsewhere on the board
/VDDA0V9_PMU: C227.1, U201.20 (LDO3); also elsewhere on the board
/VDDA_0V9: C226.1, U201.21 (LDO2); also elsewhere on the board
/VDD_CPU: C248.1, C249.1, C250.1, C251.1, C252.1, L206.2, R214.1; also elsewhere on the board
/VDD_CPU_COM: R214.2, U202.A4 (FB); also elsewhere on the board
/VDD_GPU: C215.1, C216.1, C217.1, L202.2, U201.8 (FB2); also elsewhere on the board
/VDD_LOGIC: C212.1, C213.1, C214.1, L201.2, U201.13 (FB1); also elsewhere on the board
/VDD_NPU: C220.1, C221.1, C222.1, L204.2, U201.64 (FB4); also elsewhere on the board
CLK32K: R209.2, R210.2; also elsewhere on the board
GND_D: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, C241.2, C242.2, C243.2, C244.2, C245.2, C246.2, C247.2, C248.2, C249.2, C250.2, C251.2, C252.2, C253.2, C254.2, C256.2, C257.2, C258.2, C259.2, C260.2, C261.2, C262.2, C263.2, C264.2, R203.2, R205.2, R212.2, R217.2, U201.14 (LRCLK), U201.15 (BCLK), U201.16 (MCLK), U201.17 (SDI), U201.19 (PDMCLK), U201.40 (HP_SNS), U201.47 (GNDREF), U201.56 (BATDIV), U201.62 (SNSP), U201.63 (SNSN), U201.69 (EP), U202.B2 (PGND), U202.B3 (PGND/PG), U202.B4 (AGND), U202.C1 (PGND), U202.C2 (PGND), U202.C3 (PGND), U202.C4 (PGND), U203.1 (GND), U204.2 (GND), U205.2 (GND); also elsewhere on the board
I2C0_SCL: R207.1, U202.A3 (SCL); also elsewhere on the board
I2C0_SDA: R206.1, U202.B1 (SDA); also elsewhere on the board
PMIC_1P8A: C237.1, U201.44 (VCC_1P8A)
PMIC_1P8D: C238.1, U201.48 (VCC_1P8D)
PMIC_CLK32K: R209.1, U201.68 (CLK32K)
PMIC_FB3: R202.2, R203.1, U201.27 (FB3)
PMIC_FB5: R204.2, R205.1, U201.59 (FB5)
PMIC_INT_L: U201.7 (INT); also elsewhere on the board
PMIC_LDO1: C225.1, U201.23 (LDO1)
PMIC_LDO4: C228.1, U201.28 (LDO4)
PMIC_LDO9: C233.1, U201.6 (LDO9)
PMIC_PWRON: C243.1, TP202.1, U201.52 (PWRON)
PMIC_SCL: R207.2, U201.1 (SCL)
PMIC_SDA: R206.2, U201.2 (SDA)
PMIC_SLEEP_H: U201.49 (SLEEP), U202.A1 (VSEL); also elsewhere on the board
PMIC_SW1: L201.1, U201.12 (SW1)
PMIC_SW2: L202.1, U201.9 (SW2)
PMIC_SW3: L203.1, U201.25 (SW3)
PMIC_SW4: L204.1, U201.65 (SW4)
PMIC_SW5: L205.1, U201.53 (SW5)
PMIC_VCC_SPK: C211.1, R201.2, U201.33 (VCC_SPK_HP)
PMIC_VDC: C244.1, R211.2, R212.1, U201.61 (VDC)
PMIC_VREF: C236.1, U201.46 (VREF)
PMIC_XIN: C240.1, U201.50 (XIN), Y201.1
PMIC_XOUT: C241.1, U201.51 (XOUT), Y201.2
RESETn: C242.1, R208.2, U201.67 (RESETB); also elsewhere on the board

Notes on the sheet:
PMIC RK809-5 (datasheet Rockchip RK809 Rev 2.3; schema come Rockchip RK3568 AIoT REF V1.1 pag. 22 e Radxa ROCK 3A): ingressi VCC1-VCC9 da VCC3V3_SYS, I2C0 0x20. Serie 2xx.
Default RK809-5 (tabella 4-4): BUCK1 0.9 V seq 1, BUCK2 0.9 V seq 2, BUCK3 da partitore seq 3, BUCK4 SPENTO (0.5 V), BUCK5 1.8 V seq 2, LDO2/3 0.9 V seq 1, LDO5 3.3 V seq 4, LDO6 3.3 V seq 2, LDO7/8 1.8 V seq 2, SWOUT1/2 seq 4.
BUCK4 parte spento a 0.5 V: non puo' essere il 3.3 V di sistema (resterebbe tutto spento). Il 3.3 V resta sul TPS563201 (VCC3V3_SYS) come nel reference Rockchip; BUCK4 alimenta VDD_NPU (come ROCK 3A).
Codec non usato (nota del reference): pin 14, 15, 16, 17, 19, 40 a VSS; 18, 32, 34-39, 41-43 flottanti. VCC_SPK_HP (33) da VCC3V3_SYS: il datasheet chiede VCC_RTC (45) = tensione piu' alta dell'RK809.
VCC_RTC (45) a VCC3V3_SYS con 1 uF (fig. 1-2 del datasheet, senza batteria). VDC (61) da 5V_SYS con 100k/22k = 0.9 V (>0.55 V: accensione al fronte di salita). BATDIV/SNSP/SNSN a GND. EXT_EN libero.
Ingressi (reference AIoT): VCC1 22 uF, VCC2/VCC3/VCC4/VCC9 10 uF, VCC5-VCC8 1 uF, tutti vicino ai pin.
BUCK: induttori 0.47 uH 2520 (DCR < 50 mohm, datasheet: 0.47 uH/4 A BUCK1/2/5, 3 A BUCK3/4). FB1/FB2/FB4 sulle uscite (VDD_LOGIC/GPU/NPU), come il reference.
BUCK3 VCC_DDR = 0.8 V x (1 + 62k/120k) = 1.21 V per DDR4 (tabella del reference: DDR4 1.21 V con 62K 1%).
BUCK5 VCC_1V8 (1.8 V, seq 2) libero: la VCCQ dell'eMMC e VCCIO2 restano sull'AP2112K-1.8 come richiesto. Test point TP201.
LDO e switch (reference AIoT): 1 uF su ogni uscita, LDO4 4.7 uF, SWOUT1 10 uF. LDO1/LDO4/LDO9 (IMAGE, ACODEC) non usati: spenti di default, solo il condensatore.
LDO2 VDDA_0V9, LDO3 VDDA0V9_PMU, LDO5 VCCIO_SD (VCCIO3), LDO6 VCC3V3_PMU (PMUIO1/2), LDO7 VCCA_1V8, LDO8 VCCA1V8_PMU, SWOUT1 VCC_3V3 (VCCIO4-7 e periferiche), SWOUT2 VCC3V3_SD (microSD).
Gestione: VREF 1 uF, VCC_1P8A/1P8D 1 uF, VCC_RTC 1 uF, quarzo 32.768 kHz Y201 con 2x 22 pF (reference). SDA/SCL 22R serie verso I2C0.
RESETB -> RESETn (nPOR del SoC) con 10k a VCC3V3_PMU e 100 nF. CLK32K (open drain) -> 0R -> CLK32K: CLK32K_IN del SoC (GPIO0_B0) e LPO dell'AP6256, 10k a VCC3V3_PMU.
PWRON con 100 nF e test point (accensione a mano). VDC: partitore da 5V_SYS, la PMIC parte da sola quando arriva l'alimentazione.
VDD_CPU: TCS4525 (datasheet TCS Ver.1.0) come reference AIoT pag. 23 e ROCK 3A: VIN da 5V_SYS, I2C0 0x1C, VSEL da PMIC_SLEEP_H, EN da VCC3V3_PMU con 51k (parte dopo LDO6).
FB (A4) = VDD_CPU_COM (sfera M15 del SoC, sense remoto) con 100R verso VDD_CPU. Induttore 0.33 uH (datasheet: 0.33 o 0.47 uH), Isat > 8 A (picco 8 A). PGND/PG (B3) a GND.
VCC3V3_SYS: TPS563201 da 5V_SYS, 3.3 V / 3 A, sempre acceso (EN 100k a 5V_SYS). Alimenta RK809-5 (VCC1-9), FUSB302B e i due LDO. Le periferiche stanno su VCC_3V3 (SWOUT1).
Vout = 0.768 V x (1 + 33.2k/10k) = 3.32 V. Carico stimato 2.5-3 A di picco (bucks RK809 + SWOUT1/2): al limite dei 3 A, vedi punti aperti.
VCC1V8_EMMC: AP2112K-1.8TRG1 (LCSC C176944) da VCC3V3_SYS per VCCQ dell'eMMC e VCCIO2 (FLASH_VOL_SEL alto). EN da VCC3V3_PMU: sale con la sequenza della PMIC.
VCC2V5_DDR (VPP della DDR4): AP2112K-2.5TRG1 da VCC3V3_SYS, EN da VCC3V3_PMU (seq 2, prima di VCC_DDR seq 3: VPP >= VDD come chiede JEDEC). Uscita 2x 4.7 uF + 2x 100 nF (reference).
