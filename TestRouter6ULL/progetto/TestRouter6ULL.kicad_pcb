# Repository manvalan/MuonScope (continued)

## KiCad design SchedaH616/progetto-kicad/SchedaRK3568.kicad_pcb (continued)

Schematic: cpu.kicad_sch

Parts:
C301, C302: 18pF/50V; C_0603_1608Metric
C303: 100nF; C_0603_1608Metric
C304: 1nF; C_0603_1608Metric
C305, C307, C311, C317, C324, C334, C335: 4.7uF; C_0402_1005Metric
C306, C308, C309, C310, C316, C323, C328, C332, C333, C338, C340, C342, C344, C346, C347, C348, C349, C350, C351, C353, C354, C355, C356, C357, C358, C359, C360: 100nF; C_0402_1005Metric
C312, C313, C314, C320, C321, C325, C326, C329, C330: 22uF; C_0603_1608Metric
C315: 22uF; C_0603_1608Metric; not fitted
C318, C319, C337, C339, C341, C343, C345, C352, C361: 1uF; C_0402_1005Metric
C322, C327, C331, C336: 10uF; C_0603_1608Metric
C362, C363: 1nF; C_0402_1005Metric
FB301, FB302: 120R@100MHz; L_0603_1608Metric; MPN BLM18PG121SN1D
J301: UART2 debug; PinHeader_1x03_P2.54mm_Vertical
R301: 22R; R_0603_1608Metric
R302: 1M; R_0603_1608Metric
R303: 0R; R_0603_1608Metric
R304, R305, R310, R311, R312, R313, R329, R330, R331, R332, R333, R335: 10k; R_0603_1608Metric
R306, R307, R308, R309, R338, R339: 2.2k; R_0603_1608Metric
R314, R315: 2.2R; R_0402_1005Metric
R316: 120R 1%; R_0402_1005Metric
R317, R318, R319, R320, R321, R322: 33R; R_0603_1608Metric
R323, R324, R325, R326, R327, R328: 100R; R_0603_1608Metric
R334: 100k; R_0603_1608Metric
R336, R337: 4.7k; R_0603_1608Metric
SW301: RESET; SW_Push_1P1T_NO_CK_KMR2; MPN TS-1088-AR02016
SW302: RECOVERY; SW_Push_1P1T_NO_CK_KMR2; MPN TS-1088-AR02016
U301: RK3568; Rockchip_FCBGA-636_19x19mm_P0.65mm; MPN RK3568; LCSC C2938930
U302, U303, U304, U305, U306, U307: TPD4E05U06DQA; USON-10_2.5x1.0mm_P0.5mm
Y301: 24MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN X322524MOB4SI

Connections:
/CPU/FLASH_VOL_SEL: R304.2, U301.AG25 (FLASH_VOL_SEL/GPIO0_A7)
/CPU/SARADC_VIN0: C304.1, R305.2, SW302.1, U301.B27 (SARADC_VIN0)
/CPU/SOC_ADDR_0: R323.1, U301.AG6 (GPIO2_D0)
/CPU/SOC_ADDR_1: R324.1, U301.AD7 (GPIO2_D1)
/CPU/SOC_ADDR_2: R325.1, U301.AC8 (GPIO2_D2)
/CPU/SOC_DDR_RZQ: R316.1, U301.H7 (DDR_RZQ)
/CPU/SOC_PREFIX_0: R326.1, U301.AC7 (GPIO2_D3)
/CPU/SOC_PREFIX_1: R327.1, U301.AB8 (GPIO3_A1)
/CPU/SOC_PREFIX_2: R328.1, U301.AE5 (GPIO3_A2)
/CPU/SPI3_CLK: R317.1, U301.AF8 (SPI3_CLK_M1/GPIO4_C2)
/CPU/SPI3_MISO: R319.1, U301.AD8 (SPI3_MISO_M1/GPIO4_C5)
/CPU/SPI3_MOSI: R318.1, U301.AA11 (SPI3_MOSI_M1/GPIO4_C3)
/CPU/TSADC_SHUT: R303.1, U301.AG26 (TSADC_SHUT_M0/GPIO0_A1)
/CPU/UART2_RX: J301.2, U301.AC20 (UART2_RX_M0/GPIO0_D0)
/CPU/UART2_TX: J301.1, U301.AH24 (UART2_TX_M0/GPIO0_D1)
/CPU/USB_AVDD_0V9: C305.1, C306.1, FB301.2, U301.P22 (USB3_AVDD_0V9)
/CPU/USB_AVDD_1V8: C307.1, C308.1, FB302.2, U301.P23 (USB3_AVDD_1V8)
/CPU/USB_OTG0_DM_S: R315.2, U301.P28 (USB3_OTG0_DM)
/CPU/USB_OTG0_DP_S: R314.2, U301.P27 (USB3_OTG0_DP)
/CPU/XIN24M: C302.1, R302.1, U301.AF28 (XIN24M), Y301.3
/CPU/XOUT24M: R301.1, R302.2, U301.AF27 (XOUT24M)
/CPU/XTAL24_X1: C301.1, R301.2, Y301.1
/DAC61402_FAULT: R335.2, U301.AG1 (GPIO3_B1), U304.1 (D1+); also elsewhere on the board
/I2C1_SCL: R308.2, U301.AG24 (I2C1_SCL/GPIO0_B3); also elsewhere on the board
/I2C1_SDA: R309.2, U301.AB20 (I2C1_SDA/GPIO0_B4); also elsewhere on the board
/MAIN_HIT_N: R337.2, U301.AF4 (GPIO3_A4), U307.4 (D2+); also elsewhere on the board
/MAIN_I2C_SCL: R338.2, U301.AE2 (I2C3_SCL_M1/GPIO3_B5), U305.2 (D1-); also elsewhere on the board
/MAIN_I2C_SDA: R339.2, U301.AE3 (I2C3_SDA_M1/GPIO3_B6), U305.1 (D1+); also elsewhere on the board
/MAIN_SPI_ADDR_0: R323.2, U305.5 (D2-); also elsewhere on the board
/MAIN_SPI_ADDR_1: R324.2, U306.1 (D1+); also elsewhere on the board
/MAIN_SPI_ADDR_2: R325.2, U306.2 (D1-); also elsewhere on the board
/MAIN_SPI_ALERT_N: R336.2, U301.AG4 (GPIO3_A3), U307.2 (D1-); also elsewhere on the board
/MAIN_SPI_CS_MASTER: R332.2, U301.AF6 (SPI2_CS0_M1/GPIO2_D5), U305.4 (D2+); also elsewhere on the board
/MAIN_SPI_MISO: R322.2, U304.5 (D2-); also elsewhere on the board
/MAIN_SPI_MOSI: R321.2, U304.4 (D2+); also elsewhere on the board
/MAIN_SPI_PREFIX_0: R326.2, U306.4 (D2+); also elsewhere on the board
/MAIN_SPI_PREFIX_1: R327.2, U306.5 (D2-); also elsewhere on the board
/MAIN_SPI_PREFIX_2: R328.2, U307.1 (D1+); also elsewhere on the board
/MAIN_SPI_SCLK: R320.2, U304.2 (D1-); also elsewhere on the board
/OTG_VBUSDET: U301.M24 (USB3_OTG0_VBUSDET); also elsewhere on the board
/PD_INT_N: R311.2, U301.AC22 (GPIO0_B5); also elsewhere on the board
/PWR_SPI_DAC_CS: R331.2, U301.AH7 (GPIO4_C4), U303.2 (D1-); also elsewhere on the board
/PWR_SPI_INA239A_CS: R329.2, U301.AE8 (SPI3_CS0_M1/GPIO4_C6), U302.5 (D2-); also elsewhere on the board
/PWR_SPI_INA239B_CS: R330.2, U301.AH6 (SPI3_CS1_M1/GPIO4_D1), U303.1 (D1+); also elsewhere on the board
/PWR_SPI_MISO: R319.2, U302.4 (D2+); also elsewhere on the board
/PWR_SPI_MOSI: R318.2, U302.2 (D1-); also elsewhere on the board
/PWR_SPI_SCLK: R317.2, U302.1 (D1+); also elsewhere on the board
/PWR_SRC_ST: R313.2, U301.AH26 (GPIO0_B7); also elsewhere on the board
/USB0_DM: R315.1; also elsewhere on the board
/USB0_DP: R314.1; also elsewhere on the board
/VBIAS_ENABLE: R334.1, U301.AG2 (GPIO3_B0), U303.5 (D2-); also elsewhere on the board
/VBUS_SRC_EN: U301.AF25 (GPIO0_A5); also elsewhere on the board
/VCC1V8_EMMC: C351.1, C352.1, U301.H18 (VCCIO2); also elsewhere on the board
/VCC3V3_PMU: C349.1, C350.1, R304.1, R306.1, R307.1, R308.1, R309.1, R310.1, R311.1, R312.1, R313.1, U301.W19 (PMUIO2), U301.Y20 (PMUIO1); also elsewhere on the board
/VCCA1V8_PMU: C341.1, C342.1, U301.Y21 (PMUPLL_AVDD_1V8); also elsewhere on the board
/VCCA_1V8: C345.1, C346.1, C347.1, C348.1, FB302.1, R305.1, U301.H20 (OTP_VCC18), U301.H22 (SARADC_AVDD_1V8), U301.N10 (SYSPLL_AVDD_1V8); also elsewhere on the board
/VCCIO_SD: C353.1, U301.L22 (VCCIO3); also elsewhere on the board
/VCC_3V3: C309.1, C354.1, C355.1, C356.1, C357.1, C358.1, C359.1, C360.1, C361.1, R329.1, R330.1, R331.1, R332.1, R335.1, R336.1, R337.1, R338.1, R339.1, U301.J21 (VCCIO4), U301.M23 (USB3_AVDD_3V3), U301.R9 (VCCIO6_1), U301.U9 (VCCIO6_2), U301.V10 (VCCIO5_1), U301.V11 (VCCIO5_2), U301.V12 (VCCIO7); also elsewhere on the board
/VCC_DDR: C332.1, C333.1, C334.1, C335.1, C336.1, C362.2, U301.H9 (DDRPHY_VDDQ_1), U301.H11 (DDRPHY_VDDQ_2), U301.H12 (DDRPHY_VDDQ_3), U301.H14 (DDRPHY_VDDQ_4), U301.H15 (DDRPHY_VDDQ_5), U301.J9 (DDRPHY_VDDQ_6), U301.J11 (DDRPHY_VDDQL_1), U301.J12 (DDRPHY_VDDQL_2), U301.J14 (DDRPHY_VDDQL_3), U301.K10 (DDRPHY_VDDQL_4), U301.L9 (DDRPHY_VDDQ_7), U301.L10 (DDRPHY_VDDQL_5), U301.M9 (DDRPHY_VDDQ_8), U301.M10 (DDRPHY_VDDQL_6); also elsewhere on the board
/VDDA0V9_PMU: C337.1, C338.1, C339.1, C340.1, U301.V19 (PMU_VDD_LOGIC_0V9), U301.V21 (PMUPLL_AVDD_0V9); also elsewhere on the board
/VDDA_0V9: C343.1, C344.1, FB301.1, U301.P11 (SYSPLL_AVDD_0V9); also elsewhere on the board
/VDD_CPU: C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, U301.J15 (VDD_CPU_1), U301.K15 (VDD_CPU_2), U301.K16 (VDD_CPU_3), U301.K17 (VDD_CPU_4), U301.K18 (VDD_CPU_5), U301.L15 (VDD_CPU_6), U301.L16 (VDD_CPU_7), U301.L17 (VDD_CPU_8), U301.L18 (VDD_CPU_9), U301.M17 (VDD_CPU_10); also elsewhere on the board
/VDD_CPU_COM: U301.M15 (VDD_CPU_COM); also elsewhere on the board
/VDD_GPU: C323.1, C324.1, C325.1, C326.1, C327.1, U301.R13 (VDD_GPU_1), U301.T13 (VDD_GPU_2), U301.U11 (VDD_GPU_3), U301.U12 (VDD_GPU_4), U301.U13 (VDD_GPU_5); also elsewhere on the board
/VDD_LOGIC: C316.1, C317.1, C318.1, C319.1, C320.1, C321.1, C322.1, U301.L12 (VDD_LOGIC_1), U301.M12 (VDD_LOGIC_2), U301.N13 (VDD_LOGIC_3), U301.N16 (VDD_LOGIC_4), U301.P13 (VDD_LOGIC_5), U301.P16 (VDD_LOGIC_6), U301.R12 (VDD_LOGIC_7), U301.R16 (VDD_LOGIC_8), U301.T12 (VDD_LOGIC_9), U301.T16 (VDD_LOGIC_10); also elsewhere on the board
/VDD_NPU: C328.1, C329.1, C330.1, C331.1, U301.M19 (VDD_NPU_1), U301.N19 (VDD_NPU_2), U301.P18 (VDD_NPU_3), U301.P19 (VDD_NPU_4), U301.P20 (VDD_NPU_5); also elsewhere on the board
/VREF_ENABLE: R333.1, U301.AH2 (GPIO3_A7), U303.4 (D2+); also elsewhere on the board
BT_HOST_WAKE: U301.AF23 (GPIO0_C1); also elsewhere on the board
BT_REG_ON: U301.AA5 (GPIO3_D5); also elsewhere on the board
BT_UART_CTS: U301.E25 (UART8_CTSn_M0/GPIO2_B2); also elsewhere on the board
BT_UART_RTS: U301.D26 (UART8_RTSn_M0/GPIO2_B1); also elsewhere on the board
BT_UART_RX: U301.E26 (UART8_RX_M0/GPIO2_C6); also elsewhere on the board
BT_UART_TX: U301.F26 (UART8_TX_M0/GPIO2_C5); also elsewhere on the board
BT_WAKE: U301.Y6 (GPIO3_D6); also elsewhere on the board
CLK32K: U301.AD23 (CLK32K_IN/GPIO0_B0); also elsewhere on the board
DDR_A0: U301.B6 (AC0/DDR4_A0); also elsewhere on the board
DDR_A1: U301.F5 (AC1/DDR4_A1); also elsewhere on the board
DDR_A2: U301.B1 (AC2/DDR4_A2); also elsewhere on the board
DDR_A3: U301.F4 (AC3/DDR4_A3); also elsewhere on the board
DDR_A4: U301.D9 (AC4/DDR4_A4); also elsewhere on the board
DDR_A5: U301.B7 (AC5/DDR4_A5); also elsewhere on the board
DDR_A6: U301.A7 (AC6/DDR4_A6); also elsewhere on the board
DDR_A7: U301.A8 (AC7/DDR4_A7); also elsewhere on the board
DDR_A8: U301.C1 (AC8/DDR4_A8); also elsewhere on the board
DDR_A9: U301.A5 (AC9/DDR4_A9); also elsewhere on the board
DDR_A10: U301.D6 (AC10/DDR4_A10); also elsewhere on the board
DDR_A11: U301.C2 (AC11/DDR4_A11); also elsewhere on the board
DDR_A12: U301.C4 (AC12/DDR4_A12); also elsewhere on the board
DDR_A13: U301.B8 (AC13/DDR4_A13); also elsewhere on the board
DDR_A14_WE_N: U301.C5 (AC14/DDR4_A14_WEn); also elsewhere on the board
DDR_A15_CAS_N: U301.E4 (AC15/DDR4_A15_CASn); also elsewhere on the board
DDR_A16_RAS_N: U301.D5 (AC16/DDR4_A16_RASn); also elsewhere on the board
DDR_ACT_N: U301.E6 (AC17/DDR4_ACTn); also elsewhere on the board
DDR_BA0: U301.E11 (AC18/DDR4_BA0); also elsewhere on the board
DDR_BA1: U301.E9 (AC19/DDR4_BA1); also elsewhere on the board
DDR_BG0: U301.F8 (AC20/DDR4_BG0); also elsewhere on the board
DDR_CKE: U301.B3 (AC22/DDR4_CKE); also elsewhere on the board
DDR_CK_N: U301.A4 (AC24/DDR4_CLKN); also elsewhere on the board
DDR_CK_P: U301.B4 (AC23/DDR4_CLKP); also elsewhere on the board
DDR_CS_N: U301.A2 (AC25/DDR4_CS0n); also elsewhere on the board
DDR_DML: U301.H5 (DDR_DM0_A/DDR4_DML_A); also elsewhere on the board
DDR_DMU: U301.J4 (DDR_DM1_A/DDR4_DMU_A); also elsewhere on the board
DDR_DQL0: U301.F2 (DDR_DQ0_A/DDR4_DQL0_A); also elsewhere on the board
DDR_DQL1: U301.H4 (DDR_DQ7_A/DDR4_DQL1_A); also elsewhere on the board
DDR_DQL2: U301.E1 (DDR_DQ1_A/DDR4_DQL2_A); also elsewhere on the board
DDR_DQL3: U301.H1 (DDR_DQ6_A/DDR4_DQL3_A); also elsewhere on the board
DDR_DQL4: U301.E2 (DDR_DQ2_A/DDR4_DQL4_A); also elsewhere on the board
DDR_DQL5: U301.J2 (DDR_DQ5_A/DDR4_DQL5_A); also elsewhere on the board
DDR_DQL6: U301.D1 (DDR_DQ3_A/DDR4_DQL6_A); also elsewhere on the board
DDR_DQL7: U301.J1 (DDR_DQ4_A/DDR4_DQL7_A); also elsewhere on the board
DDR_DQSL_N: U301.G2 (DDR_DQS0N_A/DDR4_DQSL_N_A); also elsewhere on the board
DDR_DQSL_P: U301.G1 (DDR_DQS0P_A/DDR4_DQSL_P_A); also elsewhere on the board
DDR_DQSU_N: U301.L1 (DDR_DQS1N_A/DDR4_DQSU_N_A); also elsewhere on the board
DDR_DQSU_P: U301.L2 (DDR_DQS1P_A/DDR4_DQSU_P_A); also elsewhere on the board
DDR_DQU0: U301.L4 (DDR_DQ15_A/DDR4_DQU0_A); also elsewhere on the board
DDR_DQU1: U301.N2 (DDR_DQ9_A/DDR4_DQU1_A); also elsewhere on the board
DDR_DQU2: U301.K2 (DDR_DQ12_A/DDR4_DQU2_A); also elsewhere on the board
DDR_DQU3: U301.M1 (DDR_DQ8_A/DDR4_DQU3_A); also elsewhere on the board
DDR_DQU4: U301.J6 (DDR_DQ13_A/DDR4_DQU4_A); also elsewhere on the board
DDR_DQU5: U301.L6 (DDR_DQ11_A/DDR4_DQU5_A); also elsewhere on the board
DDR_DQU6: U301.J7 (DDR_DQ14_A/DDR4_DQU6_A); also elsewhere on the board
DDR_DQU7: U301.L7 (DDR_DQ10_A/DDR4_DQU7_A); also elsewhere on the board
DDR_ODT: U301.E8 (AC27/DDR4_ODT0); also elsewhere on the board
DDR_RESET_N: U301.F11 (AC29/DDR4_RESETn); also elsewhere on the board
DDR_VREFOUT: C362.1, C363.1, U301.P8 (DDR_VREFOUT); also elsewhere on the board
EMMC_CLK_S: U301.A23 (EMMC_CLKOUT/GPIO1_C5); also elsewhere on the board
EMMC_CMD: U301.B22 (EMMC_CMD/GPIO1_C4); also elsewhere on the board
EMMC_D0: U301.A24 (EMMC_D0/GPIO1_B4); also elsewhere on the board
EMMC_D1: U301.C21 (EMMC_D1/GPIO1_B5); also elsewhere on the board
EMMC_D2: U301.B24 (EMMC_D2/GPIO1_B6); also elsewhere on the board
EMMC_D3: U301.D21 (EMMC_D3/GPIO1_B7); also elsewhere on the board
EMMC_D4: U301.A25 (EMMC_D4/GPIO1_C0); also elsewhere on the board
EMMC_D5: U301.E21 (EMMC_D5/GPIO1_C1); also elsewhere on the board
EMMC_D6: U301.E22 (EMMC_D6/GPIO1_C2); also elsewhere on the board
EMMC_D7: U301.B25 (EMMC_D7/GPIO1_C3); also elsewhere on the board
EMMC_DS: U301.A26 (EMMC_DATA_STROBE/GPIO1_C6); also elsewhere on the board
EMMC_RST: U301.F20 (EMMC_RSTn/GPIO1_C7); also elsewhere on the board
GND_D: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, C340.2, C341.2, C342.2, C343.2, C344.2, C345.2, C346.2, C347.2, C348.2, C349.2, C350.2, C351.2, C352.2, C353.2, C354.2, C355.2, C356.2, C357.2, C358.2, C359.2, C360.2, C361.2, C363.2, J301.3, R316.2, R333.2, R334.2, SW301.2, SW302.2, U301.A1 (VSS_1), U301.A3 (VSS_2), U301.A6 (VSS_3), U301.A10 (VSS_4), U301.A14 (VSS_5), U301.A18 (VSS_6), U301.A28 (VSS_7), U301.AA4 (VSS_133), U301.AA9 (VSS_134), U301.AA12 (AVSS_24), U301.AA14 (AVSS_25), U301.AA15 (AVSS_26), U301.AA17 (AVSS_27), U301.AA23 (VSS_135), U301.AA24 (AVSS_28), U301.AA26 (AVSS_29), U301.AB2 (VSS_136), U301.AB6 (VSS_137), U301.AB11 (AVSS_30), U301.AB12 (AVSS_31), U301.AB14 (AVSS_32), U301.AB15 (AVSS_33), U301.AB17 (AVSS_34), U301.AB24 (TVSS), U301.AC9 (AVSS_35), U301.AC11 (AVSS_36), U301.AC12 (AVSS_37), U301.AC15 (AVSS_38), U301.AC18 (AVSS_39), U301.AC25 (AVSS_40), U301.AC26 (AVSS_41), U301.AD3 (VSS_138), U301.AD26 (AVSS_42), U301.AE6 (VSS_139), U301.AE14 (AVSS_43), U301.AE17 (AVSS_44), U301.AE20 (AVSS_45), U301.AE21 (VSS_140), U301.AE27 (AVSS_46), U301.AE28 (AVSS_47), U301.AF3 (VSS_141), U301.AF9 (AVSS_48), U301.AF11 (AVSS_49), U301.AF12 (AVSS_50), U301.AF14 (AVSS_51), U301.AF15 (AVSS_52), U301.AF17 (AVSS_53), U301.AF18 (AVSS_54), U301.AF20 (AVSS_55), U301.AF21 (AVSS_56), U301.AF26 (VSS_142), U301.AG5 (VSS_143), U301.AG18 (AVSS_57), U301.AH1 (VSS_144), U301.AH8 (VSS_145), U301.AH18 (AVSS_58), U301.AH23 (AVSS_59), U301.AH28 (VSS_146), U301.B5 (VSS_8), U301.B9 (VSS_9), U301.B12 (VSS_10), U301.B16 (VSS_11), U301.B23 (VSS_12), U301.B26 (VSS_13), U301.C3 (VSS_14), U301.C6 (VSS_15), U301.C8 (VSS_16), U301.C9 (VSS_17), U301.C11 (VSS_18), U301.C12 (VSS_19), U301.C14 (VSS_20), U301.C15 (VSS_21), U301.C17 (VSS_22), U301.C18 (VSS_23), U301.C25 (VSS_24), U301.D2 (VSS_25), U301.D3 (VSS_26), U301.D11 (VSS_27), U301.D28 (VSS_28), U301.E3 (VSS_29), U301.E7 (VSS_30), U301.F1 (VSS_31), U301.F3 (VSS_32), U301.F9 (VSS_33), U301.F12 (VSS_34), U301.F14 (VSS_35), U301.F15 (VSS_36), U301.F17 (VSS_37), U301.G5 (VSS_38), U301.G6 (VSS_39), U301.G8 (VSS_40), U301.G9 (VSS_41), U301.G11 (VSS_42), U301.G12 (VSS_43), U301.G14 (VSS_44), U301.G15 (VSS_45), U301.G17 (VSS_46), U301.G18 (VSS_47), U301.G24 (VSS_48), U301.H2 (VSS_49), U301.H3 (VSS_50), U301.H6 (VSS_51), U301.J3 (VSS_52), U301.J5 (VSS_53), U301.J8 (DDR_AVSS), U301.J17 (VSS_54), U301.J18 (VSS_55), U301.J20 (VSS_56), U301.J22 (VSS_57), U301.J26 (VSS_58), U301.J27 (AVSS_1), U301.K1 (VSS_59), U301.K11 (VSS_60), U301.K12 (VSS_61), U301.K13 (VSS_62), U301.K14 (VSS_63), U301.K19 (VSS_64), U301.L3 (VSS_65), U301.L5 (VSS_66), U301.L8 (VSS_67), U301.L11 (VSS_68), U301.L13 (VSS_69), U301.L14 (VSS_70), U301.L19 (VSS_71), U301.L20 (VSS_72), U301.L21 (VSS_73), U301.L24 (AVSS_2), U301.L26 (AVSS_3), U301.M2 (VSS_74), U301.M3 (VSS_75), U301.M6 (VSS_76), U301.M8 (VSS_77), U301.M11 (VSS_78), U301.M13 (VSS_79), U301.M14 (VSS_80), U301.M16 (VSS_81), U301.M18 (VSS_82), U301.M20 (EDP_TX_AVDD_0V9), U301.M21 (AVSS_4), U301.M22 (EDP_TX_AVDD_1V8), U301.M26 (AVSS_5), U301.N1 (VSS_83), U301.N11 (SYSPLL_AVSS), U301.N12 (VSS_84), U301.N14 (VSS_85), U301.N15 (VSS_86), U301.N17 (VSS_87), U301.N18 (VSS_88), U301.N28 (AVSS_6), U301.P3 (VSS_89), U301.P6 (VSS_90), U301.P9 (USB2_AVDD_1V8), U301.P10 (USB2_AVDD_3V3), U301.P12 (VSS_91), U301.P14 (VSS_92), U301.P15 (VSS_93), U301.P17 (VSS_94), U301.P21 (AVSS_7), U301.P26 (AVSS_8), U301.R3 (VSS_95), U301.R6 (VSS_96), U301.R8 (USB2_AVDD_0V9), U301.R10 (VSS_97), U301.R11 (VSS_98), U301.R14 (VSS_99), U301.R15 (VSS_100), U301.R17 (VSS_101), U301.R18 (VSS_102), U301.R19 (VSS_103), U301.R20 (MULTI_PHY_AVDD_0V9_1), U301.R21 (MULTI_PHY_AVDD_0V9_2), U301.R22 (MULTI_PHY_AVDD_1V8), U301.R23 (AVSS_9), U301.R26 (AVSS_10), U301.T10 (VSS_104), U301.T11 (VSS_105), U301.T14 (VSS_106), U301.T15 (VSS_107), U301.T17 (VSS_108), U301.T18 (VSS_109), U301.T19 (VSS_110), U301.U1 (VSS_111), U301.U6 (VSS_112), U301.U7 (VSS_113), U301.U8 (VSS_114), U301.U10 (VSS_115), U301.U14 (VSS_116), U301.U15 (VSS_117), U301.U16 (VSS_118), U301.U17 (VSS_119), U301.U18 (VSS_120), U301.U20 (PCIE30_AVDD_0V9_2), U301.U21 (PCIE30_AVDD_0V9_1), U301.U22 (PCIE30_AVDD_1V8), U301.U23 (AVSS_11), U301.U26 (AVSS_12), U301.V3 (VSS_121), U301.V8 (VSS_122), U301.V9 (VSS_123), U301.V13 (VSS_124), U301.V14 (AVSS_13), U301.V15 (AVSS_14), U301.V16 (AVSS_15), U301.V17 (HDMI_TX_AVDD_0V9_1), U301.V18 (HDMI_TX_AVDD_0V9_2), U301.V20 (PMUPLL_AVSS), U301.V22 (AVSS_16), U301.V23 (AVSS_17), U301.V26 (AVSS_18), U301.W10 (VSS_125), U301.W11 (VSS_126), U301.W12 (VSS_127), U301.W13 (VSS_128), U301.W14 (MIPI_CSI_RX_AVDD_0V9), U301.W15 (MIPI_DSI_TX1_AVDD_0V9), U301.W16 (MIPI_DSI_TX0), U301.W17 (AVSS_19), U301.W18 (HDMI_TX_AVDD_1V8), U301.Y8 (VSS_129), U301.Y9 (VSS_130), U301.Y11 (VSS_131), U301.Y12 (VSS_132), U301.Y14 (MIPI_CSI_RX_AVDD_1V8), U301.Y15 (MIPI_DSI_TX1_AVDD_1V8), U301.Y17 (MIPI_DSI_TX0), U301.Y18 (AVSS_20), U301.Y23 (AVSS_21), U301.Y24 (AVSS_22), U301.Y26 (AVSS_23), U302.3 (GND), U302.8 (GND), U303.3 (GND), U303.8 (GND), U304.3 (GND), U304.8 (GND), U305.3 (GND), U305.8 (GND), U306.3 (GND), U306.8 (GND), U307.3 (GND), U307.8 (GND), Y301.2 (G), Y301.4 (G); also elsewhere on the board
GNSS_EXTINT: U301.AG3 (GPIO3_A6); also elsewhere on the board
GNSS_PPS: U301.AH3 (GPIO3_A5); also elsewhere on the board
GNSS_UART_RX: U301.AD2 (UART3_RX_M1/GPIO3_C0); also elsewhere on the board
GNSS_UART_TX: U301.AD4 (UART3_TX_M1/GPIO3_B7); also elsewhere on the board
I2C0_SCL: R306.2, U301.AF24 (I2C0_SCL/GPIO0_B1); also elsewhere on the board
I2C0_SDA: R307.2, U301.AB21 (I2C0_SDA/GPIO0_B2); also elsewhere on the board
PHY_EE_CS_N: U301.AF5 (SPI2_CS1_M1/GPIO2_D4); also elsewhere on the board
PHY_INT_N: U301.AA3 (GPIO4_A0); also elsewhere on the board
PHY_MDC: U301.H24 (GMAC0_MDC/GPIO2_C3); also elsewhere on the board
PHY_MDIO: U301.H23 (GMAC0_MDIO/GPIO2_C4); also elsewhere on the board
PHY_RST_N: U301.Y5 (GPIO3_D7); also elsewhere on the board
PMIC_INT_L: R310.2, U301.AA22 (GPIO0_A3); also elsewhere on the board
PMIC_SLEEP_H: U301.AG28 (PMIC_SLEEP/GPIO0_A2); also elsewhere on the board
RESETn: C303.1, R303.2, SW301.1, U301.AH27 (nPOR_u); also elsewhere on the board
RGMII_CLKIN: U301.F25 (GMAC0_MCLKINOUT/GPIO2_C2); also elsewhere on the board
RGMII_RXCK: U301.B28 (GMAC0_RXCLK/GPIO2_A5); also elsewhere on the board
RGMII_RXCTL: U301.F24 (GMAC0_RXDV_CRS/GPIO2_C0); also elsewhere on the board
RGMII_RXD0: U301.F27 (GMAC0_RXD0/GPIO2_B6); also elsewhere on the board
RGMII_RXD1: U301.H25 (GMAC0_RXD1/GPIO2_B7); also elsewhere on the board
RGMII_RXD2: U301.E27 (GMAC0_RXD2/GPIO2_A3); also elsewhere on the board
RGMII_RXD3: U301.E28 (GMAC0_RXD3/GPIO2_A4); also elsewhere on the board
RGMII_TXCK: U301.D27 (GMAC0_TXCLK/GPIO2_B0); also elsewhere on the board
RGMII_TXCTL: U301.G28 (GMAC0_TXEN/GPIO2_B5); also elsewhere on the board
RGMII_TXD0: U301.F28 (GMAC0_TXD0/GPIO2_B3); also elsewhere on the board
RGMII_TXD1: U301.G27 (GMAC0_TXD1/GPIO2_B4); also elsewhere on the board
RGMII_TXD2: U301.C27 (GMAC0_TXD2/GPIO2_A6); also elsewhere on the board
RGMII_TXD3: U301.C28 (GMAC0_TXD3/GPIO2_A7); also elsewhere on the board
SD_CLK_S: U301.H28 (SDMMC0_CLK/GPIO2_A2); also elsewhere on the board
SD_CMD: U301.H27 (SDMMC0_CMD/GPIO2_A1); also elsewhere on the board
SD_D0: U301.J25 (SDMMC0_D0/GPIO1_D5); also elsewhere on the board
SD_D1: U301.J24 (SDMMC0_D1/GPIO1_D6); also elsewhere on the board
SD_D2: U301.H26 (SDMMC0_D2/GPIO1_D7); also elsewhere on the board
SD_D3: U301.J23 (SDMMC0_D3/GPIO2_A0); also elsewhere on the board
SD_DET: U301.Y22 (SDMMC0_DET/GPIO0_A4); also elsewhere on the board
SPI2_CLK: R320.1, U301.AH4 (SPI2_CLK_M1/GPIO3_A0); also elsewhere on the board
SPI2_MISO: R322.1, U301.AH5 (SPI2_MISO_M1/GPIO2_D7); also elsewhere on the board
SPI2_MOSI: R321.1, U301.AD6 (SPI2_MOSI_M1/GPIO2_D6); also elsewhere on the board
USB1_DM: U301.P25 (USB3_HOST1_DM); also elsewhere on the board
USB1_DP: U301.P24 (USB3_HOST1_DP); also elsewhere on the board
USB1_OC_N: R312.2, U301.AA20 (GPIO0_B6); also elsewhere on the board
USB1_VBUS_EN: U301.AE24 (GPIO0_A6); also elsewhere on the board
WL_HOST_WAKE: U301.AD22 (GPIO0_C0); also elsewhere on the board
WL_REG_ON: U301.AA1 (GPIO3_D4); also elsewhere on the board
WL_SDIO_CLK_S: U301.AC1 (SDMMC2_CLK_M0/GPIO3_D3); also elsewhere on the board
WL_SDIO_CMD: U301.Y7 (SDMMC2_CMD_M0/GPIO3_D2); also elsewhere on the board
WL_SDIO_D0: U301.AC5 (SDMMC2_D0_M0/GPIO3_C6); also elsewhere on the board
WL_SDIO_D1: U301.AA6 (SDMMC2_D1_M0/GPIO3_C7); also elsewhere on the board
WL_SDIO_D2: U301.AB5 (SDMMC2_D2_M0/GPIO3_D0); also elsewhere on the board
WL_SDIO_D3: U301.AB1 (SDMMC2_D3_M0/GPIO3_D1); also elsewhere on the board

Notes on the sheet:
CPU: Rockchip RK3568 (FCBGA636L 19x19 mm, passo 0.65 mm, LCSC C2938930). Ball map: Rockchip RK3568 PinOut V1.1, verificata sulla tabella 2-1 del datasheet V1.2 (636/636). Serie 3xx.
Domini IO: PMUIO1/PMUIO2 = VCC3V3_PMU (3.3 V), VCCIO2 = VCC1V8_EMMC (1.8 V, FLASH_VOL_SEL alto), VCCIO3 = VCCIO_SD, VCCIO4-7 = VCC_3V3 (3.3 V), VCCIO1 non usato (flottante, come da Rockchip).
PHY non usati (USB2 HOST2/3, MULTI_PHY, PCIe3, MIPI CSI/DSI, HDMI, eDP): alimentazioni a VSS e segnali flottanti, secondo 'RK3568 Processing instructions for unused pins'. VDD_NPU su BUCK4 dell'RK809-5.
DDR4 a 16 bit sul canale A del PHY (DQ0-15_A, nomi DDR4_DQL/DQU_A del pinout Rockchip); canale B, ECC, CS1n, ODT1, BG1 non usati. Mappa completa in docs/pinmap-rk3568.md.
24 MHz (Hardware Design Guide RK3568 fig. 2-1 / reference AIoT): 22R serie su XOUT24M, 1M tra XIN e XOUT, 18 pF per lato (da adattare al CL del quarzo, tolleranza 20 ppm).
nPOR (AH27, dominio PMUIO1): rete RESETn con 100 nF vicino alla sfera, RESETB dell'RK809-5 (open drain, 10k a VCC3V3_PMU sul foglio PMIC), TSADC_SHUT_M0 con 0R e tasto RESET.
Il tasto RESET tira giu' RESETn: l'RK809-5 rifa' la sequenza di accensione (Hardware Design Guide, par. Reset). FLASH_VOL_SEL (GPIO0_A7) 10k a VCC3V3_PMU: VCCIO2 a 1.8 V.
Recovery (ex FEL): SARADC_VIN0 (B27) con 10k a VCCA_1V8 (obbligatorio, Rockchip) e tasto a GND: tenuto premuto all'accensione il loader entra in modalita' Recovery/rockusb.
J301 console UART2_M0 (GPIO0_D1 TX, GPIO0_D0 RX, PMUIO2 3.3 V): 1 = TX del SoC, 2 = RX del SoC, 3 = GND. 1500000 baud (default Rockchip).
I2C0 (GPIO0_B1/B2, PMUIO2): RK809-5 0x20 e TCS4525 0x1C, pull-up 2.2k a VCC3V3_PMU. I2C1 (GPIO0_B3/B4): FUSB302B 0x22, 2.2k a VCC3V3_PMU.
Open drain verso i GPIO PMU: PMIC_INT_L, PD_INT_N (FUSB302B), USB1_OC_N (TPS2553), PWR_SRC_ST (TPS2121) con 10k a VCC3V3_PMU. SD_DET 10k sul foglio Memorie.
USB3_OTG0_DP/DM (porta di flash rkdeveloptool, USB-C di alimentazione) con 2.2R in serie. USB3_HOST1_DP/DM verso la USB-C host (2.2R sul foglio USB host).
USB3_AVDD_0V9/1V8 da VDDA_0V9/VCCA_1V8 con ferrite 120R@100MHz (reference AIoT), USB3_AVDD_3V3 da VCC_3V3. USB2_AVDD (HOST2/3 non usati) a VSS.
Disaccoppiamento secondo il reference Rockchip RK3568 AIoT V1.1: 100 nF/1 nF e 4.7 uF/1 uF in 0402 sotto il package (niente 0201: troppo piccoli), 22 uF/10 uF 0603 vicino.
VDD_CPU >= 135 uF in totale con le uscite del TCS4525 (Hardware Design Guide 2.2.2.4), un 22 uF DNP di riserva. VDD_LOGIC/GPU/NPU >= 90 uF con le uscite dell'RK809-5.
C315 DNP: 22 uF di riserva su VDD_CPU (Hardware Design Guide). VCCIO4 ha due 100 nF (RGMII), VCCIO5/VCCIO6 due sfere ciascuno.
DDR_RZQ (H7): 120R 1% a GND per DDR4 (Hardware Design Guide 2.1.7.2; l'appunto diceva 240R, che vale per lo ZQ della DDR4). DDR_VREFOUT (P8): 1 nF a VCC_DDR e 1 nF a GND vicino al SoC.
BUS_POWER su SPI3_M1 (VCCIO7): CLK GPIO4_C2, MOSI GPIO4_C3, MISO GPIO4_C5, CS0 INA239A GPIO4_C6, CS1 INA239B GPIO4_D1; CS del DAC su GPIO4_C4 con cs-gpios (SPI3 ha solo due CS hardware).
MAIN su SPI2_M1 (VCCIO5): CLK GPIO3_A0, MOSI GPIO2_D6, MISO GPIO2_D7, CS0 = CS_MASTER GPIO2_D5; CS1 (GPIO2_D4) = EEPROM MAC locale. 33R serie su CLK/MOSI/MISO verso i connettori.
I2C del bus su I2C3_M1 (GPIO3_B5/B6). ADDR/PREFIX con 100R serie. Linee lente (VREF/VBIAS_ENABLE, FAULT, ALERT#, HIT#, PPS, EXTINT) su GPIO diretti: niente TCA6416A.
Livelli di riposo: CS e CS_MASTER alti (10k), VREF_ENABLE basso (10k a GND), VBIAS_ENABLE basso (100k a GND), ALERT# e HIT# 4.7k, I2C del bus 2.2k, FAULT 10k (tutti a VCC_3V3).
ESD bassa capacita TPD4E05U06DQA (0.5 pF, 5.5 V) sulle linee logiche di J1/J2, vicino ai connettori. Nessuna protezione su V_BIAS e riferimenti.

Schematic: memorie.kicad_sch

Parts:
C401: 1nF; C_0603_1608Metric; not fitted
C402, C403: 1nF; C_0402_1005Metric
C404, C405: 10uF; C_0603_1608Metric
C406, C417: 1uF; C_0402_1005Metric
C407, C408, C409, C410, C411, C412, C413, C414, C415, C416, C418: 100nF; C_0402_1005Metric
C419: 1uF/10V; C_0603_1608Metric
C420, C423: 2.2uF/10V; C_0603_1608Metric
C421, C422, C424, C425, C427: 0.1uF; C_0603_1608Metric
C426: 10uF/10V; C_0603_1608Metric
J401: DM3AT-SF-PEJM5; SD-SMD_DM3AT-SF-PEJM5; MPN DM3AT-SF-PEJM5
R401: 240R 1%; R_0402_1005Metric
R402: 0R; R_0402_1005Metric
R403, R404: 1k 1%; R_0402_1005Metric; not fitted
R405, R416: 22R; R_0402_1005Metric
R406, R407, R408, R409, R410, R411, R412, R413, R414, R415, R422: 10k; R_0603_1608Metric
R417, R418, R419, R420, R421: 47k; R_0603_1608Metric
U401: K4AAG165WA-BCWE; BGA-96_L13.3-W10.3-P0.80_K4AAG165WA-BCWE; MPN K4AAG165WA-BCWE; LCSC C2920140
U402: FEMDNN064G-C9A61; BGA-153_L13.0-W11.5-P0.50-TL_FORESEE_FEMDME; MPN FEMDNN064G-C9A61; LCSC C49284704
U403, U404: TPD4E05U06DQA; USON-10_2.5x1.0mm_P0.5mm

Connections:
/Memorie/DDR4_ZQ: R401.1, U401.F9 (ZQ)
/Memorie/VREF_DDR4_CA: C402.1, C403.1, R402.2, R403.2, R404.1, U401.M1 (VREFCA)
/VCC1V8_EMMC: C423.1, C424.1, C425.1, R406.1, R407.1, R408.1, R409.1, R410.1, R411.1, R412.1, R413.1, R414.1, R415.1, U402.C6 (VCCQ), U402.M4 (VCCQ), U402.N4 (VCCQ), U402.P3 (VCCQ), U402.P5 (VCCQ); also elsewhere on the board
/VCC2V5_DDR: C417.1, C418.1, U401.B1 (VPP), U401.R9 (VPP); also elsewhere on the board
/VCC3V3_PMU: R422.1; also elsewhere on the board
/VCC3V3_SD: C426.1, C427.1, J401.4 (VDD); also elsewhere on the board
/VCCIO_SD: R417.1, R418.1, R419.1, R420.1, R421.1; also elsewhere on the board
/VCC_3V3: C420.1, C421.1, C422.1, U402.E6 (VCC), U402.F5 (VCC), U402.J10 (VCC), U402.K9 (VCC); also elsewhere on the board
/VCC_DDR: C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, C410.1, C411.1, C412.1, C413.1, C414.1, C415.1, C416.1, R403.1, U401.A1 (VDDQ), U401.A9 (VDDQ), U401.B3 (VDD), U401.B9 (VDD), U401.C1 (VDDQ), U401.D1 (VDD), U401.D9 (VDDQ), U401.F2 (VDDQ), U401.F8 (VDDQ), U401.G1 (VDDQ), U401.G7 (VDD), U401.G9 (VDDQ), U401.J1 (VDD), U401.J2 (VDDQ), U401.J8 (VDDQ), U401.J9 (VDD), U401.L1 (VDD), U401.L9 (VDD), U401.R1 (VDD), U401.T9 (VDD); also elsewhere on the board
DDR_A0: U401.P3 (A0); also elsewhere on the board
DDR_A1: U401.P7 (A1); also elsewhere on the board
DDR_A2: U401.R3 (A2); also elsewhere on the board
DDR_A3: U401.N7 (A3); also elsewhere on the board
DDR_A4: U401.N3 (A4); also elsewhere on the board
DDR_A5: U401.P8 (A5); also elsewhere on the board
DDR_A6: U401.P2 (A6); also elsewhere on the board
DDR_A7: U401.R8 (A7); also elsewhere on the board
DDR_A8: U401.R2 (A8); also elsewhere on the board
DDR_A9: U401.R7 (A9); also elsewhere on the board
DDR_A10: U401.M3 (A10/AP); also elsewhere on the board
DDR_A11: U401.T2 (A11); also elsewhere on the board
DDR_A12: U401.M7 (A12/BC_n); also elsewhere on the board
DDR_A13: U401.T8 (A13); also elsewhere on the board
DDR_A14_WE_N: U401.L2 (WE_n/A14); also elsewhere on the board
DDR_A15_CAS_N: U401.M8 (CAS_n/A15); also elsewhere on the board
DDR_A16_RAS_N: U401.L8 (RAS_n/A16); also elsewhere on the board
DDR_ACT_N: U401.L3 (ACT_n); also elsewhere on the board
DDR_BA0: U401.N2 (BA0); also elsewhere on the board
DDR_BA1: U401.N8 (BA1); also elsewhere on the board
DDR_BG0: U401.M2 (BG0); also elsewhere on the board
DDR_CKE: U401.K2 (CKE); also elsewhere on the board
DDR_CK_N: U401.K8 (CK_c); also elsewhere on the board
DDR_CK_P: U401.K7 (CK_t); also elsewhere on the board
DDR_CS_N: U401.L7 (CS_n); also elsewhere on the board
DDR_DML: U401.E7 (DML_n/DBIL_n); also elsewhere on the board
DDR_DMU: U401.E2 (DMU_n/DBIU_n); also elsewhere on the board
DDR_DQL0: U401.G2 (DQL0); also elsewhere on the board
DDR_DQL1: U401.F7 (DQL1); also elsewhere on the board
DDR_DQL2: U401.H3 (DQL2); also elsewhere on the board
DDR_DQL3: U401.H7 (DQL3); also elsewhere on the board
DDR_DQL4: U401.H2 (DQL4); also elsewhere on the board
DDR_DQL5: U401.H8 (DQL5); also elsewhere on the board
DDR_DQL6: U401.J3 (DQL6); also elsewhere on the board
DDR_DQL7: U401.J7 (DQL7); also elsewhere on the board
DDR_DQSL_N: U401.F3 (DQSL_c); also elsewhere on the board
DDR_DQSL_P: U401.G3 (DQSL_t); also elsewhere on the board
DDR_DQSU_N: U401.A7 (DQSU_c); also elsewhere on the board
DDR_DQSU_P: U401.B7 (DQSU_t); also elsewhere on the board
DDR_DQU0: U401.A3 (DQU0); also elsewhere on the board
DDR_DQU1: U401.B8 (DQU1); also elsewhere on the board
DDR_DQU2: U401.C3 (DQU2); also elsewhere on the board
DDR_DQU3: U401.C7 (DQU3); also elsewhere on the board
DDR_DQU4: U401.C2 (DQU4); also elsewhere on the board
DDR_DQU5: U401.C8 (DQU5); also elsewhere on the board
DDR_DQU6: U401.D3 (DQU6); also elsewhere on the board
DDR_DQU7: U401.D7 (DQU7); also elsewhere on the board
DDR_ODT: U401.K3 (ODT); also elsewhere on the board
DDR_RESET_N: C401.1, U401.P1 (RESET_n); also elsewhere on the board
DDR_VREFOUT: R402.1; also elsewhere on the board
EMMC_CLK: R405.2, U402.M6 (CLK)
EMMC_CLK_S: R405.1; also elsewhere on the board
EMMC_CMD: R406.2, U402.M5 (CMD); also elsewhere on the board
EMMC_D0: R407.2, U402.A3 (DAT0); also elsewhere on the board
EMMC_D1: R408.2, U402.A4 (DAT1); also elsewhere on the board
EMMC_D2: R409.2, U402.A5 (DAT2); also elsewhere on the board
EMMC_D3: R410.2, U402.B2 (DAT3); also elsewhere on the board
EMMC_D4: R411.2, U402.B3 (DAT4); also elsewhere on the board
EMMC_D5: R412.2, U402.B4 (DAT5); also elsewhere on the board
EMMC_D6: R413.2, U402.B5 (DAT6); also elsewhere on the board
EMMC_D7: R414.2, U402.B6 (DAT7); also elsewhere on the board
EMMC_DS: U402.H5 (DS); also elsewhere on the board
EMMC_RST: R415.2, U402.K5 (RSTN); also elsewhere on the board
EMMC_VDDI: C419.1, U402.C2 (VDDI)
GND_D: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, C420.2, C421.2, C422.2, C423.2, C424.2, C425.2, C426.2, C427.2, J401.6 (VSS), J401.10, J401.11 (SW_A), J401.12, J401.13, J401.14, R401.2, R404.2, U401.A2 (VSSQ), U401.A8 (VSSQ), U401.B2 (VSS), U401.C9 (VSSQ), U401.D2 (VSSQ), U401.D8 (VSSQ), U401.E1 (VSS), U401.E3 (VSSQ), U401.E8 (VSSQ), U401.E9 (VSS), U401.F1 (VSSQ), U401.G8 (VSS), U401.H1 (VSSQ), U401.H9 (VSSQ), U401.K1 (VSS), U401.K9 (VSS), U401.M9 (VSS), U401.N1 (VSS), U401.N9 (TEN), U401.T1 (VSS), U401.T3 (PAR), U402.A6 (VSS), U402.C4 (VSSQ), U402.E7 (VSS), U402.G5 (VSS), U402.H10 (VSS), U402.J5 (VSS), U402.K8 (VSS), U402.N2 (VSSQ), U402.N5 (VSSQ), U402.P4 (VSSQ), U402.P6 (VSSQ), U403.3 (GND), U403.8 (GND), U404.3 (GND), U404.8 (GND); also elsewhere on the board
SD_CLK: J401.5 (CLK), R416.2, U403.1 (D1+)
SD_CLK_S: R416.1; also elsewhere on the board
SD_CMD: J401.3 (CMD), R417.2, U403.2 (D1-); also elsewhere on the board
SD_D0: J401.7 (DAT0), R418.2, U403.4 (D2+); also elsewhere on the board
SD_D1: J401.8 (DAT1), R419.2, U403.5 (D2-); also elsewhere on the board
SD_D2: J401.1 (DAT2), R420.2, U404.1 (D1+); also elsewhere on the board
SD_D3: J401.2 (CD/DAT3), R421.2, U404.2 (D1-); also elsewhere on the board
SD_DET: J401.9 (SW_B), R422.2, U404.4 (D2+); also elsewhere on the board

Notes on the sheet:
MEMORIE: DDR4 x16 (1 chip, point-to-point, niente VTT), eMMC 8 bit su EMMC (VCCIO2 1.8 V), microSD su SDMMC0 (VCCIO3). Serie 4xx.
U401 Samsung K4AAG165WA-BCWE (LCSC C2920140, 16 Gbit = 2 GB, x16, DDR4-3200): VDD/VDDQ = VCC_DDR 1.2 V (BUCK3), VPP = VCC2V5_DDR (AP2112K-2.5). Collegata al canale A del PHY dell'RK3568.
DQ/DM/DQS secondo il pinout Rockchip (DDR_DQx_A -> DDR4_DQL/DQU_A): l'ordine dei bit nel byte e' quello del template Rockchip, i CA non si possono scambiare (Hardware Design Guide 2.1.7).
ZQ 240R 1% a GND, TEN e PAR a GND, ALERT_n libero, T7 (NC/A17) libero (reference Rockchip DDR4 16bit SDP). RESET_n con 1 nF DNP (anti-ESD, Hardware Design Guide).
VREFCA da DDR_VREFOUT del SoC (P8, 0.6 V di default) con 0R; 2x 1 nF vicino alla DDR4 (valore da non cambiare, Hardware Design Guide). Partitore 1k/1k DNP come alternativa.
Disaccoppiamento DDR4 (reference, ridotto a un chip): VCC_DDR 2x 10 uF + 1 uF + 10x 100 nF; VPP 1 uF + 100 nF vicino alle sfere B1/R9.
U402 eMMC FORESEE FEMDNN064G-C9A61 (64 GB, eMMC 5.1 HS400, LCSC C49284704): VCC = VCC_3V3, VCCQ = VCC1V8_EMMC (AP2112K-1.8, = VCCIO2: HS200/HS400). CLK 22R serie vicino al SoC (reference), pull-up 10k su CMD/DAT0-7/RST_n.
J401 microSD (Hirose DM3AT) su SDMMC0: VDD = VCC3V3_SD (SWOUT2 dell'RK809-5), segnali a VCCIO_SD (LDO5, 3.3 V, 1.8 V per UHS). CLK 22R serie, pull-up 47k a VCCIO_SD.
SD_DET su SDMMC0_DET (GPIO0_A4, PMUIO1) con 10k a VCC3V3_PMU: basso con la scheda inserita = SDMMC0 (alto = JTAG sui pin SDMMC0, Hardware Design Guide).
ESD TPD4E05U06DQA vicino allo slot: CLK (lato slot), CMD, DAT0-3, DET.

Schematic: rete.kicad_sch

Parts:
C501, C514: 100nF; C_0603_1608Metric
C502, C503: 15pF; C_0603_1608Metric
C504: 22uF; C_0603_1608Metric
C505, C506, C507, C508, C510, C511, C512, C513, C515: 0.1uF; C_0603_1608Metric
C509: 10uF; C_0603_1608Metric
J501: HR911130C; RJ45-TH_HR911130C; MPN HR911130C
L501: 2.2uH; L_0805_2012Metric
R501, R502, R503, R504, R505, R506, R524, R525, R526, R527, R528, R529: 22R; R_0402_1005Metric
R507, R508, R509, R510, R511, R512, R513, R514, R515, R517: 4.7k; R_0603_1608Metric
R516: 1.5k; R_0603_1608Metric
R518, R521: 10k; R_0603_1608Metric
R519: 2.49k 1%; R_0603_1608Metric
R520: 0R; R_0603_1608Metric; not fitted
R522, R523: 510R; R_0603_1608Metric
U501: RTL8211F-CG; QFN40P500X500X90-41N; MPN RTL8211F-CG
U502: 25AA02E48T-I/OT; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; MPN 25AA02E48T-I/OT
Y501: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/Rete/ETH_CT: C514.1, J501.P1
/Rete/ETH_LED1_A: J501.11, R522.2
/Rete/ETH_LED2_A: J501.14, R523.2
/Rete/MDI0_N: J501.P3 (MDI0-), U501.2 (MDIN0)
/Rete/MDI0_P: J501.P2 (MDI0+), U501.1 (MDIP0)
/Rete/MDI1_N: J501.P7 (MDI1-), U501.5 (MDIN1)
/Rete/MDI1_P: J501.P4 (MDI1+), U501.4 (MDIP1)
/Rete/MDI2_N: J501.P6 (MDI2-), U501.7 (MDIN2)
/Rete/MDI2_P: J501.P5 (MDI2+), U501.6 (MDIP2)
/Rete/MDI3_N: J501.P9 (MDI3-), U501.10 (MDIN3)
/Rete/MDI3_P: J501.P8 (MDI3+), U501.9 (MDIP3)
/VCC_3V3: C509.1, C510.1, C511.1, C512.1, C513.1, C515.1, R507.1, R511.1, R512.1, R513.1, R516.1, R517.1, R518.1, R521.1, U501.11 (AVDD33), U501.28 (DVDD_RG), U501.29 (DVDD33), U501.40 (AVDD33), U502.6 (VDD); also elsewhere on the board
GND_D: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, J501.12, J501.13, J501.P10, J501.SHIELD0, J501.SHIELD1, R508.2, R509.2, R510.2, R514.2, R515.2, R519.2, U501.41 (EPAD_GND), U502.2 (VSS), Y501.2 (G), Y501.4 (G); also elsewhere on the board
PHY_CLKOUT: R520.1, U501.35 (CLKOUT)
PHY_EE_CS_N: R521.2, U502.5 (~CS); also elsewhere on the board
PHY_INT_N: R517.2, U501.31 (INTB/PMEB); also elsewhere on the board
PHY_LED0: R513.2, U501.32 (LED0/CFG_EXT)
PHY_LED1: R514.1, R522.1, U501.33 (LED1/CFG_LDO0)
PHY_LED2: R515.1, R523.1, U501.34 (LED2/CFG_LDO1)
PHY_MDC: U501.13 (MDC); also elsewhere on the board
PHY_MDIO: R516.2, U501.14 (MDIO); also elsewhere on the board
PHY_REG_OUT: L501.1, U501.30 (REG_OUT)
PHY_RSET: R519.1, U501.39 (RSET)
PHY_RST_N: C501.1, R518.2, U501.12 (PHYRSTB); also elsewhere on the board
PHY_RXCTL_P: R509.1, R529.1, U501.26 (RXCTL/PHYAD2)
PHY_RXC_P: R508.1, R524.1, U501.27 (RXC/PHYAD1)
PHY_RXD0_P: R512.2, R525.1, U501.25 (RXD0/RXDLY)
PHY_RXD1_P: R511.2, R526.1, U501.24 (RXD1/TXDLY)
PHY_RXD2_P: R510.1, R527.1, U501.23 (RXD2/PLLOFF)
PHY_RXD3_P: R507.2, R528.1, U501.22 (RXD3/PHYAD0)
PHY_TXCTL_P: R506.2, U501.19 (TXCTL)
PHY_TXC_P: R501.2, U501.20 (TXC)
PHY_TXD0_P: R502.2, U501.18 (TXD0)
PHY_TXD1_P: R503.2, U501.17 (TXD1)
PHY_TXD2_P: R504.2, U501.16 (TXD2)
PHY_TXD3_P: R505.2, U501.15 (TXD3)
PHY_VDD10: C504.1, C505.1, C506.1, C507.1, C508.1, L501.2, U501.3 (AVDD10), U501.8 (AVDD10), U501.21 (DVDD10), U501.38 (AVDD10)
PHY_XI: C502.1, U501.36 (XTAL_IN), Y501.1
PHY_XO: C503.1, U501.37 (XTAL_OUT), Y501.3
RGMII_CLKIN: R520.2; also elsewhere on the board
RGMII_RXCK: R524.2; also elsewhere on the board
RGMII_RXCTL: R529.2; also elsewhere on the board
RGMII_RXD0: R525.2; also elsewhere on the board
RGMII_RXD1: R526.2; also elsewhere on the board
RGMII_RXD2: R527.2; also elsewhere on the board
RGMII_RXD3: R528.2; also elsewhere on the board
RGMII_TXCK: R501.1; also elsewhere on the board
RGMII_TXCTL: R506.1; also elsewhere on the board
RGMII_TXD0: R502.1; also elsewhere on the board
RGMII_TXD1: R503.1; also elsewhere on the board
RGMII_TXD2: R504.1; also elsewhere on the board
RGMII_TXD3: R505.1; also elsewhere on the board
SPI2_CLK: U502.1 (SCK); also elsewhere on the board
SPI2_MISO: U502.4 (SO); also elsewhere on the board
SPI2_MOSI: U502.3 (SI); also elsewhere on the board

Notes on the sheet:
RETE: PHY Realtek RTL8211F-CG (datasheet rev. 1.7) su GMAC0 RGMII dell'RK3568 (VCCIO4 3.3 V), alimentato da VCC_3V3 (SWOUT1). Serie 5xx. Net RGMII_*/PHY_* globali verso il foglio CPU.
Strap (4.7k): PHYAD = 001, PLLOFF = 0, TXDLY = 1 e RXDLY = 1 (rgmii-id, ritardi nel PHY), CFG_EXT = 1 con CFG_LDO = 00: pad RGMII alimentati da fuori a 3.3 V.
22R serie vicino al SoC su TXC, TXD0-3, TXCTL (MAC -> PHY) e vicino al PHY su RXC, RXD0-3, RXCTL (Hardware Design Guide RK3568, tabella 2-42).
Strap su RXD/RXC/RXCTL e LED (4.7k). LED1/LED2 attivi alti verso i LED dell'RJ45 (510R); LED0 solo strap CFG_EXT.
MDIO 1.5k a 3.3 V, INT 4.7k, PHYRSTB 10k + 100 nF (il PHY esce dal reset da solo, Linux puo' ripeterlo da GPIO3_D7). RSET 2.49k 1%.
R520 DNP: CLKOUT 125 MHz verso GMAC0_MCLKINOUT (GPIO2_C2), non usato di default. PHY_RST_N su GPIO3_D7, PHY_INT_N su GPIO4_A0.
Quarzo 25 MHz +-50 ppm (requisito datasheet) con 2x 15 pF. Switching regulator 1.0 V: REG_OUT -> 2.2 uH -> AVDD10/DVDD10.
RJ45 HanRun HR911130C (100/1000Base-T, magnetici e LED integrati). Prese centrali lato PHY (P1, comuni) a GND con 100 nF. P10 = rete Bob Smith verso lo schermo.
LED verde = LED1 del PHY (100M), giallo = LED2 (1000M), entrambi attivi alti.
EEPROM MAC 25AA02E48 (EUI-48 per la MAC del GMAC0) su SPI2 locale (prima dei 33R verso il bus MAIN), CS1 hardware di SPI2 (GPIO2_D4) con 10k a VCC_3V3.
Pinout SOT-23-6 dal datasheet Microchip DS20002123G, tabella 4-1: 1 SCK, 2 VSS, 3 SI, 4 SO, 5 CS, 6 VCC.

Schematic: radio.kicad_sch

Parts:
C601: 10uF; C_0603_1608Metric
C602, C605: 0.1uF; C_0603_1608Metric
C603: 4.7uF; C_0603_1608Metric
C604: 1uF; C_0603_1608Metric
C606, C607: DNP; C_0603_1608Metric; not fitted
J601: U.FL; U.FL_Hirose_U.FL-R-SMT-1_Vertical
R601, R602: 100k; R_0603_1608Metric
R603, R604, R605, R606, R607: 10k; R_0603_1608Metric
R608: 0R; R_0603_1608Metric
R609: 22R; R_0402_1005Metric
U601: AP6256; AP6256_LGA-47_12x12mm; MPN AP6256

Connections:
/VCC_3V3: C601.1, C602.1, C604.1, C605.1, R603.1, R604.1, R605.1, R606.1, R607.1, U601.9 (VBAT), U601.22 (VDDIO), U601.23 (VIN_LDO); also elsewhere on the board
BT_HOST_WAKE: U601.7 (BT_HOST_WAKE); also elsewhere on the board
BT_REG_ON: R602.1, U601.34 (BT_REG_ON); also elsewhere on the board
BT_UART_CTS: U601.41 (UART_RTS_N); also elsewhere on the board
BT_UART_RTS: U601.44 (UART_CTS_N); also elsewhere on the board
BT_UART_RX: U601.42 (UART_TXD); also elsewhere on the board
BT_UART_TX: U601.43 (UART_RXD); also elsewhere on the board
BT_WAKE: U601.6 (BT_WAKE); also elsewhere on the board
CLK32K: U601.24 (LPO); also elsewhere on the board
GND_D: C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, J601.2 (Ext), R601.2, R602.2, U601.1 (GND), U601.3 (GND), U601.20 (GND), U601.29 (SDIO_VSEL), U601.31 (GND), U601.33 (GND), U601.36 (GND); also elsewhere on the board
WL_ANT: C606.1, R608.1, U601.2 (WL_BT_ANT)
WL_ANT_C: C607.1, J601.1 (In), R608.2
WL_HOST_WAKE: U601.13 (WL_HOST_WAKE); also elsewhere on the board
WL_LDO_OUT: C603.1, U601.21 (VIN_LDO_OUT)
WL_REG_ON: R601.1, U601.12 (WL_REG_ON); also elsewhere on the board
WL_SDIO_CLK: R609.2, U601.17 (SDIO_DATA_CLK)
WL_SDIO_CLK_S: R609.1; also elsewhere on the board
WL_SDIO_CMD: R603.2, U601.16 (SDIO_DATA_CMD); also elsewhere on the board
WL_SDIO_D0: R604.2, U601.18 (SDIO_DATA_0); also elsewhere on the board
WL_SDIO_D1: R605.2, U601.19 (SDIO_DATA_1); also elsewhere on the board
WL_SDIO_D2: R606.2, U601.14 (SDIO_DATA_2); also elsewhere on the board
WL_SDIO_D3: R607.2, U601.15 (SDIO_DATA_3); also elsewhere on the board

Notes on the sheet:
RADIO: AMPAK AP6256 (Wi-Fi 5 + BT 5.0) su SDMMC2_M0 (SDIO, VCCIO6), HCI su UART8_M0 con RTS/CTS (VCCIO4), REG_ON e wake su GPIO. Serie 6xx. Net WL_*/BT_*/CLK32K globali.
VDDIO = VCC_3V3 3.3 V (= VCCIO6/VCCIO4), SDIO 2.0 fino a 50 MHz. VBAT e VIN_LDO da VCC_3V3. LPO 32.768 kHz da CLK32K dell'RK809-5 (quarzo Y201).
UART incrociata: TXD del modulo -> BT_UART_RX (UART8_RX, GPIO2_C6), RXD <- BT_UART_TX (GPIO2_C5), RTS_N -> BT_UART_CTS (GPIO2_B2), CTS_N <- BT_UART_RTS (GPIO2_B1).
PCM (25-28) non collegati: niente audio Bluetooth. XTAL_IN/OUT liberi (quarzo interno). GPIO e TP liberi.
REG_ON con 100k a GND (radio spenta finche Linux non la accende: GPIO3_D4/D5). Pull-up 10k su CMD e DAT0-3 a VCC_3V3. CLK 22R serie vicino al SoC.
Disaccoppiamento: VBAT 10uF + 0.1uF (picchi 1 A in trasmissione), VIN_LDO_OUT 4.7uF, VDDIO 1uF + 0.1uF.
Antenna: linea 50 ohm verso U.FL con rete pi di adattamento (0R + 2x DNP) da tarare.

Schematic: gnss.kicad_sch

Parts:
BT701: CR1220; BatteryHolder_MYOUNG_BS-12-B3AA003_CR1220; MPN BS-12-B3AA003
C701: 10uF; C_0603_1608Metric
C702, C705, C706: 0.1uF; C_0603_1608Metric
C703: 1uF; C_0603_1608Metric
C704: 10nF; C_0603_1608Metric
D701, D704: BAT54; D_SOD-323
D702: ESD5V3U1U-02LS; D_0402_1005Metric
D703: ESD9B5.0ST5G; D_SOD-923
J701: SMA antenna; SMA_Amphenol_132289_EdgeMount
J702: SMA PPS OUT; SMA_Amphenol_132289_EdgeMount
J703: SMA STROBE IN; SMA_Amphenol_132289_EdgeMount
J704: PPS/STROBE; PinHeader_1x03_P2.54mm_Vertical
L701: 27nH; L_0402_1005Metric
R702: 10R; R_0603_1608Metric
R703, R704: 33R; R_0603_1608Metric
R705: 100R; R_0603_1608Metric
R706: 100k; R_0603_1608Metric
TP701: SAFEBOOT_N; TestPoint_Pad_D1.0mm
TP702: RESET_N; TestPoint_Pad_D1.0mm
U701: NEO-M9N-00B; ublox_NEO; MPN NEO-M9N-00B
U702, U703: 74LVC1G17; SOT-353_SC-70-5

Connections:
/VCC_3V3: C701.1, C702.1, C705.1, C706.1, D701.2 (A), U701.23 (VCC), U702.5 (VCC), U703.5 (VCC); also elsewhere on the board
GND_D: BT701.2 (-), C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, D702.2 (A2), D703.2 (A2), J701.2 (Ext), J702.2 (Ext), J703.2 (Ext), J704.3, R706.2, U701.7 (VDD_USB), U701.10 (GND), U701.12 (GND), U701.13 (GND), U701.24 (GND), U702.3 (GND), U703.3 (GND); also elsewhere on the board
GNSS_ANT_BIAS: C704.1, L701.1, R702.2
GNSS_BAT: BT701.1 (+), D704.2 (A)
GNSS_EXTINT: U701.4 (EXTINT), U703.4; also elsewhere on the board
GNSS_PPS: R703.2; also elsewhere on the board
GNSS_PPS_BUF: R704.1, U702.4
GNSS_PPS_OUT: J702.1 (In), J704.1, R704.2
GNSS_RESET_N: TP702.1, U701.8 (~RESET)
GNSS_RF_IN: D702.1 (A1), J701.1 (In), L701.2, U701.11 (RF_IN)
GNSS_SAFEBOOT_N: TP701.1, U701.1 (~SAFEBOOT)
GNSS_STROBE_IN: D703.1 (A1), J703.1 (In), J704.2, R705.1
GNSS_STROBE_R: R705.2, R706.1, U703.2
GNSS_TP: R703.1, U701.3 (TIMEPULSE), U702.2
GNSS_UART_RX: U701.20 (TXD/SPI_MISO); also elsewhere on the board
GNSS_UART_TX: U701.21 (RXD/SPI_MOSI); also elsewhere on the board
GNSS_VCC_RF: R702.1, U701.9 (VCC_RF)
GNSS_V_BCKP: C703.1, D701.1 (K), D704.1 (K), U701.22 (V_BCKP)

Notes on the sheet:
GNSS: u-blox NEO-M9N-00B (formato NEO, stesso footprint del NEO-F10T). Pin dal datasheet UBX-19014285 R08, tabella 9 (= simbolo NEO-M9N di KiCad). Serie 7xx.
UART3_M1: TXD del modulo -> GNSS_UART_RX (GPIO3_C0), RXD <- GNSS_UART_TX (GPIO3_B7). TIMEPULSE -> 33R -> GNSS_PPS (GPIO3_A5). EXTINT (pin 4, PIO7, time mark TIM-TM2) letto anche da GPIO3_A6 (solo ingresso).
D_SEL (pin 2) aperto = UART + I2C. V_USB (pin 7) a GND: USB non usata (da confermare sull'integration manual). LNA_EN e riservati liberi.
Alimentazione: VCC 10uF + 0.1uF. Backup V_BCKP da OR di diodi: VCC_3V3 (BAT54) e pila CR1220 (BAT54), nessuna ricarica della pila.
Antenna attiva su SMA: VCC_RF -> 10R (limita il corto) -> 27 nH -> RF_IN. ESD a bassa capacita sul centrale. Linea 50 ohm corta.
Uscita PPS: TIMEPULSE -> 33R -> GNSS_PPS (SoC) e -> buffer 74LVC1G17 -> 33R -> SMA 'PPS OUT' e header J703. Nessun pull sul TIMEPULSE.
Time mark: SMA 'STROBE IN' (o J703 pin 2) -> ESD -> 100R -> 74LVC1G17 (ingressi tolleranti 5 V) -> EXTINT. 100k a GND in ingresso.
