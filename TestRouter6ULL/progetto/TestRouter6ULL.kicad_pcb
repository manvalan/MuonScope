# Repository manvalan/MuonScope (continued)

## KiCad design PianoMatrice/PianoMatrice.kicad_pcb (continued)

Schematic: bus-pnp.kicad_sch

Parts:
C1201, C1202, C1203, C1204, C1205, C1206, C1207, C1208, C1209, C1210: 100nF; C_0603_1608Metric
C1211, C1212: 10uF; C_0805_2012Metric
C1213, C1214: 100nF/100V; C_1206_3216Metric
C1215: 27pF C0G; C_0603_1608Metric
C1216, C1217: 1uF; C_0603_1608Metric
D1201, D1202, D1203, D1204, D1205, D1206, D1207, D1208, D1209, D1210, D1211, D1212, D1213, D1214, D1215, D1216, D1217, D1218, D1219, D1220: TPD1E10B06; D_0402_1005Metric; MPN TPD1E10B06DPYR
J1201: J_IN MAIN; FPC-05F-28PH20; MPN FPC-05F-28PH20
J1202: J_OUT MAIN; FPC-05F-28PH20; MPN FPC-05F-28PH20
R1201: 0R; R_0603_1608Metric
R1202, R1203, R1204, R1205, R1206: 100k; R_0603_1608Metric
R1207: 2k; R_0603_1608Metric
U1201: 74HC283; TSSOP-16_4.4x5mm_P0.65mm; MPN 74HC283PW
U1202: 74HC85; TSSOP-16_4.4x5mm_P0.65mm; MPN 74HC85PW
U1203: 74HC138; TSSOP-16_4.4x5mm_P0.65mm; MPN 74HC138PW
U1204: SN74LVC2G17DBVR; SOT-23-6; MPN SN74LVC2G17DBVR
U1205: SN74LVC1G125DBVR; SOT-23-5; MPN SN74LVC1G125DBVR
U1206: SN74LVC1G332DBVR; SOT-23-6; MPN SN74LVC1G332DBVR
U1207: SN74LVC1G07DBVR; SOT-23-5; MPN SN74LVC1G07DBVR
U1208: 25AA02E48T-I/SN; SOIC-8_3.9x4.9mm_P1.27mm; MPN 25AA02E48T-I/SN
U1209: SN74LVC1G123DCUR; VSSOP-8_2.3x2mm_P0.5mm; MPN SN74LVC1G123DCUR
U1210: SN74LVC1G06DBVR; SOT-23-5; MPN SN74LVC1G06DBVR

Connections:
1V25_REF: C1217.1, J1201.6, J1202.6; also elsewhere on the board
2V5_REF: C1216.1, J1201.5, J1202.5; also elsewhere on the board
+3V3: C1201.1, C1202.1, C1203.1, C1204.1, C1205.1, C1206.1, C1207.1, C1208.1, C1209.1, C1210.1, C1211.1, J1201.3, J1202.3, R1202.1, R1207.1, U1201.7 (CIN), U1201.16 (VCC), U1202.3 (IA=B), U1202.16 (VCC), U1203.16 (VCC), U1204.5 (VCC), U1205.5 (VCC), U1206.5 (VCC), U1207.5 (VCC), U1208.3 (~WP), U1208.7 (~HOLD), U1208.8 (VCC), U1209.3 (~CLR), U1209.8 (VCC), U1210.5 (VCC); also elsewhere on the board
+5V: C1212.1, J1201.2, J1202.2; also elsewhere on the board
/bus-pnp/AGTB: U1202.5 (QA>B), U1206.3 (B)
/bus-pnp/ALTB: U1202.7 (QA<B), U1206.6 (C)
/bus-pnp/BUS_ADDR0: D1207.1 (A1), J1201.18, J1202.18, U1203.1 (A0)
/bus-pnp/BUS_ADDR1: D1208.1 (A1), J1201.19, J1202.19, U1203.2 (A1)
/bus-pnp/BUS_ADDR2: D1209.1 (A1), J1201.20, J1202.20, U1203.3 (A2)
/bus-pnp/BUS_ALERT_N: D1213.1 (A1), J1201.24, J1202.24, U1207.4 (Y)
/bus-pnp/BUS_CS_MASTER: D1206.1 (A1), J1201.17, J1202.17, R1202.2, U1203.4 (~E1), U1206.1 (A)
/bus-pnp/BUS_HIT_N: D1214.1 (A1), J1201.28, J1202.28, U1210.4 (Y)
/bus-pnp/BUS_MISO: D1203.1 (A1), J1201.13, J1202.13, U1205.4 (Y)
/bus-pnp/BUS_MOSI: D1202.1 (A1), J1201.12, J1202.12, U1204.3 (2A)
/bus-pnp/BUS_PREFIX0: D1210.1 (A1), J1201.21, J1202.21, U1202.10 (A0)
/bus-pnp/BUS_PREFIX1: D1211.1 (A1), J1201.22, J1202.22, U1202.12 (A1)
/bus-pnp/BUS_PREFIX2: D1212.1 (A1), J1201.23, J1202.23, U1202.13 (A2)
/bus-pnp/BUS_SCLK: D1201.1 (A1), J1201.11, J1202.11, U1204.1 (1A)
/bus-pnp/CS_EEP: U1203.9 (~Y6), U1208.1 (~CS)
/bus-pnp/GND_A: J1201.7, J1202.7, R1201.1
/bus-pnp/HIT_PULSE: U1209.5 (Q), U1210.2 (A)
/bus-pnp/ID_IN0: D1215.1 (A1), J1201.25, R1204.1, U1201.5 (A1), U1202.9 (B0)
/bus-pnp/ID_IN1: D1216.1 (A1), J1201.26, R1205.1, U1201.3 (A2), U1202.11 (B1)
/bus-pnp/ID_IN2: D1217.1 (A1), J1201.27, R1206.1, U1201.14 (A3), U1202.14 (B2)
/bus-pnp/ID_OUT0: D1218.1 (A1), J1202.25, U1201.4 (S1)
/bus-pnp/ID_OUT1: D1219.1 (A1), J1202.26, U1201.1 (S2)
/bus-pnp/ID_OUT2: D1220.1 (A1), J1202.27, U1201.13 (S3)
/bus-pnp/MISO_OE_N: U1205.1 (~OE), U1206.4 (Y)
/bus-pnp/MONO_C: C1215.2, U1209.6 (Cext)
/bus-pnp/MONO_RC: C1215.1, R1207.2, U1209.7 (Rext/Cext)
/bus-pnp/PL_SEL: U1202.6 (QA=B), U1203.6 (E3)
CS_ADC: U1203.15 (~Y0); also elsewhere on the board
CS_DAC: U1203.14 (~Y1); also elsewhere on the board
CS_HITMAP: U1203.10 (~Y5); also elsewhere on the board
CS_INA: U1203.13 (~Y2); also elsewhere on the board
CS_MCP: U1203.7 (~Y7); also elsewhere on the board
CS_Y3: U1203.12 (~Y3); also elsewhere on the board
CS_Y4: U1203.11 (~Y4); also elsewhere on the board
GND: C1201.2, C1202.2, C1203.2, C1204.2, C1205.2, C1206.2, C1207.2, C1208.2, C1209.2, C1210.2, C1211.2, C1212.2, C1213.2, C1214.2, C1216.2, C1217.2, D1201.2 (A2), D1202.2 (A2), D1203.2 (A2), D1204.2 (A2), D1205.2 (A2), D1206.2 (A2), D1207.2 (A2), D1208.2 (A2), D1209.2 (A2), D1210.2 (A2), D1211.2 (A2), D1212.2 (A2), D1213.2 (A2), D1214.2 (A2), D1215.2 (A2), D1216.2 (A2), D1217.2 (A2), D1218.2 (A2), D1219.2 (A2), D1220.2 (A2), J1201.1, J1201.4, J1201.10, J1201.16, J1201.MP (MountPin), J1202.1, J1202.4, J1202.10, J1202.16, J1202.MP (MountPin), R1201.2, R1203.2, R1204.2, R1205.2, R1206.2, U1201.2 (B2), U1201.6 (B1), U1201.8 (GND), U1201.11 (B4), U1201.12 (A4), U1201.15 (B3), U1202.1 (B3), U1202.2 (IA<B), U1202.4 (IA>B), U1202.8 (GND), U1202.15 (A3), U1203.5 (~E2), U1203.8 (GND), U1204.2 (GND), U1205.3 (GND), U1206.2 (GND), U1207.3 (GND), U1208.4 (VSS), U1209.1 (~A), U1209.4 (GND), U1210.3 (GND); also elsewhere on the board
HIT_ANY: U1209.2 (B); also elsewhere on the board
I2C_SCL: D1205.1 (A1), J1201.15, J1202.15; also elsewhere on the board
I2C_SDA: D1204.1 (A1), J1201.14, J1202.14; also elsewhere on the board
MCP_INTA: U1207.2 (A); also elsewhere on the board
MISO_L: R1203.1, U1205.2 (A), U1208.2 (SO); also elsewhere on the board
MOSI_L: U1204.4 (2Y), U1208.5 (SI); also elsewhere on the board
SCLK_L: U1204.6 (1Y), U1208.6 (SCK); also elsewhere on the board
VHV_36V: C1213.1, J1201.8, J1202.8; also elsewhere on the board
VHV_36V_2: C1214.1, J1201.9, J1202.9

Notes on the sheet:
BUS MIKILAB REV5.1 - MAIN 28 pin, come il PianoTest. Y0 ADC, Y1 DAC, Y2 INA, Y3 reset latch e picchi, Y4 gradino di test, Y5 mappa dei colpi (MCP), Y6 EEPROM ID, Y7 MCP di controllo.
HIT# (pin 28): HIT_ANY -> monostabile 74LVC1G123 (2k + 27 pF, ~170-200 ns) -> 74LVC1G06 open-drain. ALERT#: INTA dell'MCP di controllo via 74LVC1G07.

Schematic: canali.kicad_sch

Parts:
C10, C30: 100nF/100V C0G; C_1206_3216Metric; MPN C3216C0G2A104J160AE
C11, C31: ${CF} C0G; C_0402_1005Metric
C12, C32: Cf2; C_0402_1005Metric; not fitted
C13, C33: 0.5pF C0G; C_0402_1005Metric
C14, C16, C34, C36: 1nF C0G; C_0402_1005Metric
C15, C35: 20pF C0G; C_0402_1005Metric
C50, C51, C52, C53, C54: 100nF; C_0402_1005Metric
D1, D2: VBPW34S; XDCR_VBPW34S; MPN VBPW34S
D10, D30: BAS416; D_SOD-323; MPN BAS416
Q10, Q30: BSS138; SOT-23
R10, R30: 1k; R_0603_1608Metric
R11, R31: ${RF}; R_0805_2012Metric
R12, R32: Rf2; R_0805_2012Metric; not fitted
R14, R16, R19, R34, R36, R39: 1k; R_0402_1005Metric
R15, R35: 49.9k; R_0402_1005Metric
R17, R37: 0R; R_0402_1005Metric
R18, R38: trim; R_0402_1005Metric; not fitted
U1: OPA4140AIPWR; TSSOP-14_4.4x5mm_P0.65mm; MPN OPA4140AIPWR
U2: TLV3502AIDGKR; VSSOP-8_3x3mm_P0.65mm; MPN TLV3502AIDGKR
U3: SN74LVC74APWR; TSSOP-14_4.4x5mm_P0.65mm; MPN SN74LVC74APWR
U4: OPA2365AIDR; SOIC-8_3.9x4.9mm_P1.27mm; MPN OPA2365AIDR

Parts of its further copies:
C110, C130, C210, C230, C310, C330, C410, C430, C510, C530, C610, C630, C710, C730, C810, C830: 100nF/100V C0G; C_1206_3216Metric; MPN C3216C0G2A104J160AE
C112, C132, C212, C232, C312, C332, C412, C432, C512, C532, C612, C632, C712, C732, C812, C832: Cf2; C_0402_1005Metric; not fitted
C113, C133, C213, C233, C313, C333, C413, C433, C513, C533, C613, C633, C713, C733, C813, C833: 0.5pF C0G; C_0402_1005Metric
C114, C116, C134, C136, C214, C216, C234, C236, C314, C316, C334, C336, C414, C416, C434, C436, C514, C516, C534, C536, C614, C616, C634, C636, C714, C716, C734, C736, C814, C816, C834, C836: 1nF C0G; C_0402_1005Metric
C115, C135, C215, C235, C315, C335, C415, C435, C515, C535, C615, C635, C715, C735, C815, C835: 20pF C0G; C_0402_1005Metric
C150, C151, C152, C153, C154, C250, C251, C252, C253, C254, C350, C351, C352, C353, C354, C450, C451, C452, C453, C454, C550, C551, C552, C553, C554, C650, C651, C652, C653, C654, C750, C751, C752, C753, C754, C850, C851, C852, C853, C854: 100nF; C_0402_1005Metric
D101, D102, D201, D202, D301, D302, D401, D402, D501, D502, D601, D602, D701, D702, D801, D802: VBPW34S; XDCR_VBPW34S; MPN VBPW34S
D110, D130, D210, D230, D310, D330, D410, D430, D510, D530, D610, D630, D710, D730, D810, D830: BAS416; D_SOD-323; MPN BAS416
Q110, Q130, Q210, Q230, Q310, Q330, Q410, Q430, Q510, Q530, Q610, Q630, Q710, Q730, Q810, Q830: BSS138; SOT-23
R110, R130, R210, R230, R310, R330, R410, R430, R510, R530, R610, R630, R710, R730, R810, R830: 1k; R_0603_1608Metric
R112, R132, R212, R232, R312, R332, R412, R432, R512, R532, R612, R632, R712, R732, R812, R832: Rf2; R_0805_2012Metric; not fitted
R114, R116, R119, R134, R136, R139, R214, R216, R219, R234, R236, R239, R314, R316, R319, R334, R336, R339, R414, R416, R419, R434, R436, R439, R514, R516, R519, R534, R536, R539, R614, R616, R619, R634, R636, R639, R714, R716, R719, R734, R736, R739, R814, R816, R819, R834, R836, R839: 1k; R_0402_1005Metric
R115, R135, R215, R235, R315, R335, R415, R435, R515, R535, R615, R635, R715, R735, R815, R835: 49.9k; R_0402_1005Metric
R117, R137, R217, R237, R317, R337, R417, R437, R517, R537, R617, R637, R717, R737, R817, R837: 0R; R_0402_1005Metric
R118, R138, R218, R238, R318, R338, R418, R438, R518, R538, R618, R638, R718, R738, R818, R838: trim; R_0402_1005Metric; not fitted
U101, U201, U301, U401, U501, U601, U701, U801: OPA4140AIPWR; TSSOP-14_4.4x5mm_P0.65mm; MPN OPA4140AIPWR
U102, U202, U302, U402, U502, U602, U702, U802: TLV3502AIDGKR; VSSOP-8_3x3mm_P0.65mm; MPN TLV3502AIDGKR
U103, U203, U303, U403, U503, U603, U703, U803: SN74LVC74APWR; TSSOP-14_4.4x5mm_P0.65mm; MPN SN74LVC74APWR
U104, U204, U304, U404, U504, U604, U704, U804: OPA2365AIDR; SOIC-8_3.9x4.9mm_P1.27mm; MPN OPA2365AIDR

Connections of its further copies:
1V25_REF: U101.3 (+INA), U101.5 (+INB), U101.10 (+INC), U101.12 (+IND), U201.3 (+INA), U201.5 (+INB), U201.10 (+INC), U201.12 (+IND), U301.3 (+INA), U301.5 (+INB), U301.10 (+INC), U301.12 (+IND), U401.3 (+INA), U401.5 (+INB), U401.10 (+INC), U401.12 (+IND), U501.3 (+INA), U501.5 (+INB), U501.10 (+INC), U501.12 (+IND), U601.3 (+INA), U601.5 (+INB), U601.10 (+INC), U601.12 (+IND), U701.3 (+INA), U701.5 (+INB), U701.10 (+INC), U701.12 (+IND), U801.3 (+INA), U801.5 (+INB), U801.10 (+INC), U801.12 (+IND); also elsewhere on the board
+3V3: C152.1, C153.1, C154.1, C252.1, C253.1, C254.1, C352.1, C353.1, C354.1, C452.1, C453.1, C454.1, C552.1, C553.1, C554.1, C652.1, C653.1, C654.1, C752.1, C753.1, C754.1, C852.1, C853.1, C854.1, U102.8 (V+), U103.2 (1D), U103.4 (~1PRE), U103.10 (~2PRE), U103.12 (2D), U103.14 (VCC), U104.8 (V+), U202.8 (V+), U203.2 (1D), U203.4 (~1PRE), U203.10 (~2PRE), U203.12 (2D), U203.14 (VCC), U204.8 (V+), U302.8 (V+), U303.2 (1D), U303.4 (~1PRE), U303.10 (~2PRE), U303.12 (2D), U303.14 (VCC), U304.8 (V+), U402.8 (V+), U403.2 (1D), U403.4 (~1PRE), U403.10 (~2PRE), U403.12 (2D), U403.14 (VCC), U404.8 (V+), U502.8 (V+), U503.2 (1D), U503.4 (~1PRE), U503.10 (~2PRE), U503.12 (2D), U503.14 (VCC), U504.8 (V+), U602.8 (V+), U603.2 (1D), U603.4 (~1PRE), U603.10 (~2PRE), U603.12 (2D), U603.14 (VCC), U604.8 (V+), U702.8 (V+), U703.2 (1D), U703.4 (~1PRE), U703.10 (~2PRE), U703.12 (2D), U703.14 (VCC), U704.8 (V+), U802.8 (V+), U803.2 (1D), U803.4 (~1PRE), U803.10 (~2PRE), U803.12 (2D), U803.14 (VCC), U804.8 (V+); also elsewhere on the board
+5V: C150.1, C151.1, C250.1, C251.1, C350.1, C351.1, C450.1, C451.1, C550.1, C551.1, C650.1, C651.1, C750.1, C751.1, C850.1, C851.1, U101.4 (V+), U201.4 (V+), U301.4 (V+), U401.4 (V+), U501.4 (V+), U601.4 (V+), U701.4 (V+), U801.4 (V+); also elsewhere on the board
/Canali00-01/CMP_A: U102.7 (OUTA), U103.3 (1CLK)
/Canali00-01/CMP_B: U102.6 (OUTB), U103.11 (2CLK)
/Canali00-01/CP_A: R116.2, U102.1 (+INA)
/Canali00-01/CP_B: R136.2, U102.3 (+INB)
/Canali00-01/CSA_A: C112.1, C113.2, D101.A, R112.1, U101.2 (-INA); also elsewhere on the board
/Canali00-01/CSA_B: C132.1, C133.2, D102.A, R132.1, U101.6 (-INB); also elsewhere on the board
/Canali00-01/CSO_A: C112.2, C114.1, R112.2, U101.1 (OUTA); also elsewhere on the board
/Canali00-01/CSO_B: C132.2, C134.1, R132.2, U101.7 (OUTB); also elsewhere on the board
/Canali00-01/DK_A: C110.1, D101.K, R110.2
/Canali00-01/DK_B: C130.1, D102.K, R130.2
/Canali00-01/PKI_A: R119.2, U104.3 (+INA)
/Canali00-01/PKI_B: R139.2, U104.5 (+INB)
/Canali00-01/PKO_A: D110.2 (A), U104.1 (OUTA)
/Canali00-01/PKO_B: D130.2 (A), U104.7 (OUTB)
/Canali00-01/SD_A: C114.2, R114.1
/Canali00-01/SD_B: C134.2, R134.1
/Canali00-01/SHO_A: C115.2, R115.2, R116.1, R119.1, U101.8 (OUTC)
/Canali00-01/SHO_B: C135.2, R135.2, R136.1, R139.1, U101.14 (OUTD)
/Canali00-01/SUM_A: C115.1, R114.2, R115.1, U101.9 (-INC)
/Canali00-01/SUM_B: C135.1, R134.2, R135.1, U101.13 (-IND)
/Canali00-01/VTH_A: R117.2, R118.1, U102.2 (-INA)
/Canali00-01/VTH_B: R137.2, R138.1, U102.4 (-INB)
/Canali02-03/CMP_A: U202.7 (OUTA), U203.3 (1CLK)
/Canali02-03/CMP_B: U202.6 (OUTB), U203.11 (2CLK)
/Canali02-03/CP_A: R216.2, U202.1 (+INA)
/Canali02-03/CP_B: R236.2, U202.3 (+INB)
/Canali02-03/CSA_A: C212.1, C213.2, D201.A, R212.1, U201.2 (-INA); also elsewhere on the board
/Canali02-03/CSA_B: C232.1, C233.2, D202.A, R232.1, U201.6 (-INB); also elsewhere on the board
/Canali02-03/CSO_A: C212.2, C214.1, R212.2, U201.1 (OUTA); also elsewhere on the board
/Canali02-03/CSO_B: C232.2, C234.1, R232.2, U201.7 (OUTB); also elsewhere on the board
/Canali02-03/DK_A: C210.1, D201.K, R210.2
/Canali02-03/DK_B: C230.1, D202.K, R230.2
/Canali02-03/PKI_A: R219.2, U204.3 (+INA)
/Canali02-03/PKI_B: R239.2, U204.5 (+INB)
/Canali02-03/PKO_A: D210.2 (A), U204.1 (OUTA)
/Canali02-03/PKO_B: D230.2 (A), U204.7 (OUTB)
/Canali02-03/SD_A: C214.2, R214.1
/Canali02-03/SD_B: C234.2, R234.1
/Canali02-03/SHO_A: C215.2, R215.2, R216.1, R219.1, U201.8 (OUTC)
/Canali02-03/SHO_B: C235.2, R235.2, R236.1, R239.1, U201.14 (OUTD)
/Canali02-03/SUM_A: C215.1, R214.2, R215.1, U201.9 (-INC)
/Canali02-03/SUM_B: C235.1, R234.2, R235.1, U201.13 (-IND)
/Canali02-03/VTH_A: R217.2, R218.1, U202.2 (-INA)
/Canali02-03/VTH_B: R237.2, R238.1, U202.4 (-INB)
/Canali04-05/CMP_A: U302.7 (OUTA), U303.3 (1CLK)
/Canali04-05/CMP_B: U302.6 (OUTB), U303.11 (2CLK)
/Canali04-05/CP_A: R316.2, U302.1 (+INA)
/Canali04-05/CP_B: R336.2, U302.3 (+INB)
/Canali04-05/CSA_A: C312.1, C313.2, D301.A, R312.1, U301.2 (-INA); also elsewhere on the board
/Canali04-05/CSA_B: C332.1, C333.2, D302.A, R332.1, U301.6 (-INB); also elsewhere on the board
/Canali04-05/CSO_A: C312.2, C314.1, R312.2, U301.1 (OUTA); also elsewhere on the board
/Canali04-05/CSO_B: C332.2, C334.1, R332.2, U301.7 (OUTB); also elsewhere on the board
/Canali04-05/DK_A: C310.1, D301.K, R310.2
/Canali04-05/DK_B: C330.1, D302.K, R330.2
/Canali04-05/PKI_A: R319.2, U304.3 (+INA)
/Canali04-05/PKI_B: R339.2, U304.5 (+INB)
/Canali04-05/PKO_A: D310.2 (A), U304.1 (OUTA)
/Canali04-05/PKO_B: D330.2 (A), U304.7 (OUTB)
/Canali04-05/SD_A: C314.2, R314.1
/Canali04-05/SD_B: C334.2, R334.1
/Canali04-05/SHO_A: C315.2, R315.2, R316.1, R319.1, U301.8 (OUTC)
/Canali04-05/SHO_B: C335.2, R335.2, R336.1, R339.1, U301.14 (OUTD)
/Canali04-05/SUM_A: C315.1, R314.2, R315.1, U301.9 (-INC)
/Canali04-05/SUM_B: C335.1, R334.2, R335.1, U301.13 (-IND)
/Canali04-05/VTH_A: R317.2, R318.1, U302.2 (-INA)
/Canali04-05/VTH_B: R337.2, R338.1, U302.4 (-INB)
/Canali06-07/CMP_A: U402.7 (OUTA), U403.3 (1CLK)
/Canali06-07/CMP_B: U402.6 (OUTB), U403.11 (2CLK)
/Canali06-07/CP_A: R416.2, U402.1 (+INA)
/Canali06-07/CP_B: R436.2, U402.3 (+INB)
/Canali06-07/CSA_A: C412.1, C413.2, D401.A, R412.1, U401.2 (-INA); also elsewhere on the board
/Canali06-07/CSA_B: C432.1, C433.2, D402.A, R432.1, U401.6 (-INB); also elsewhere on the board
/Canali06-07/CSO_A: C412.2, C414.1, R412.2, U401.1 (OUTA); also elsewhere on the board
/Canali06-07/CSO_B: C432.2, C434.1, R432.2, U401.7 (OUTB); also elsewhere on the board
/Canali06-07/DK_A: C410.1, D401.K, R410.2
/Canali06-07/DK_B: C430.1, D402.K, R430.2
/Canali06-07/PKI_A: R419.2, U404.3 (+INA)
/Canali06-07/PKI_B: R439.2, U404.5 (+INB)
/Canali06-07/PKO_A: D410.2 (A), U404.1 (OUTA)
/Canali06-07/PKO_B: D430.2 (A), U404.7 (OUTB)
/Canali06-07/SD_A: C414.2, R414.1
/Canali06-07/SD_B: C434.2, R434.1
/Canali06-07/SHO_A: C415.2, R415.2, R416.1, R419.1, U401.8 (OUTC)
/Canali06-07/SHO_B: C435.2, R435.2, R436.1, R439.1, U401.14 (OUTD)
/Canali06-07/SUM_A: C415.1, R414.2, R415.1, U401.9 (-INC)
/Canali06-07/SUM_B: C435.1, R434.2, R435.1, U401.13 (-IND)
/Canali06-07/VTH_A: R417.2, R418.1, U402.2 (-INA)
/Canali06-07/VTH_B: R437.2, R438.1, U402.4 (-INB)
/Canali08-09/CMP_A: U502.7 (OUTA), U503.3 (1CLK)
/Canali08-09/CMP_B: U502.6 (OUTB), U503.11 (2CLK)
/Canali08-09/CP_A: R516.2, U502.1 (+INA)
/Canali08-09/CP_B: R536.2, U502.3 (+INB)
/Canali08-09/CSA_A: C512.1, C513.2, D501.A, R512.1, U501.2 (-INA); also elsewhere on the board
/Canali08-09/CSA_B: C532.1, C533.2, D502.A, R532.1, U501.6 (-INB); also elsewhere on the board
/Canali08-09/CSO_A: C512.2, C514.1, R512.2, U501.1 (OUTA); also elsewhere on the board
/Canali08-09/CSO_B: C532.2, C534.1, R532.2, U501.7 (OUTB); also elsewhere on the board
/Canali08-09/DK_A: C510.1, D501.K, R510.2
/Canali08-09/DK_B: C530.1, D502.K, R530.2
/Canali08-09/PKI_A: R519.2, U504.3 (+INA)
/Canali08-09/PKI_B: R539.2, U504.5 (+INB)
/Canali08-09/PKO_A: D510.2 (A), U504.1 (OUTA)
/Canali08-09/PKO_B: D530.2 (A), U504.7 (OUTB)
/Canali08-09/SD_A: C514.2, R514.1
/Canali08-09/SD_B: C534.2, R534.1
/Canali08-09/SHO_A: C515.2, R515.2, R516.1, R519.1, U501.8 (OUTC)
/Canali08-09/SHO_B: C535.2, R535.2, R536.1, R539.1, U501.14 (OUTD)
/Canali08-09/SUM_A: C515.1, R514.2, R515.1, U501.9 (-INC)
/Canali08-09/SUM_B: C535.1, R534.2, R535.1, U501.13 (-IND)
/Canali08-09/VTH_A: R517.2, R518.1, U502.2 (-INA)
/Canali08-09/VTH_B: R537.2, R538.1, U502.4 (-INB)
/Canali10-11/CMP_A: U602.7 (OUTA), U603.3 (1CLK)
/Canali10-11/CMP_B: U602.6 (OUTB), U603.11 (2CLK)
/Canali10-11/CP_A: R616.2, U602.1 (+INA)
/Canali10-11/CP_B: R636.2, U602.3 (+INB)
/Canali10-11/CSA_A: C612.1, C613.2, D601.A, R612.1, U601.2 (-INA); also elsewhere on the board
/Canali10-11/CSA_B: C632.1, C633.2, D602.A, R632.1, U601.6 (-INB); also elsewhere on the board
/Canali10-11/CSO_A: C612.2, C614.1, R612.2, U601.1 (OUTA); also elsewhere on the board
/Canali10-11/CSO_B: C632.2, C634.1, R632.2, U601.7 (OUTB); also elsewhere on the board
/Canali10-11/DK_A: C610.1, D601.K, R610.2
/Canali10-11/DK_B: C630.1, D602.K, R630.2
/Canali10-11/PKI_A: R619.2, U604.3 (+INA)
/Canali10-11/PKI_B: R639.2, U604.5 (+INB)
/Canali10-11/PKO_A: D610.2 (A), U604.1 (OUTA)
/Canali10-11/PKO_B: D630.2 (A), U604.7 (OUTB)
/Canali10-11/SD_A: C614.2, R614.1
/Canali10-11/SD_B: C634.2, R634.1
/Canali10-11/SHO_A: C615.2, R615.2, R616.1, R619.1, U601.8 (OUTC)
/Canali10-11/SHO_B: C635.2, R635.2, R636.1, R639.1, U601.14 (OUTD)
/Canali10-11/SUM_A: C615.1, R614.2, R615.1, U601.9 (-INC)
/Canali10-11/SUM_B: C635.1, R634.2, R635.1, U601.13 (-IND)
/Canali10-11/VTH_A: R617.2, R618.1, U602.2 (-INA)
/Canali10-11/VTH_B: R637.2, R638.1, U602.4 (-INB)
/Canali12-13/CMP_A: U702.7 (OUTA), U703.3 (1CLK)
/Canali12-13/CMP_B: U702.6 (OUTB), U703.11 (2CLK)
/Canali12-13/CP_A: R716.2, U702.1 (+INA)
/Canali12-13/CP_B: R736.2, U702.3 (+INB)
/Canali12-13/CSA_A: C712.1, C713.2, D701.A, R712.1, U701.2 (-INA); also elsewhere on the board
/Canali12-13/CSA_B: C732.1, C733.2, D702.A, R732.1, U701.6 (-INB); also elsewhere on the board
/Canali12-13/CSO_A: C712.2, C714.1, R712.2, U701.1 (OUTA); also elsewhere on the board
/Canali12-13/CSO_B: C732.2, C734.1, R732.2, U701.7 (OUTB); also elsewhere on the board
/Canali12-13/DK_A: C710.1, D701.K, R710.2
/Canali12-13/DK_B: C730.1, D702.K, R730.2
/Canali12-13/PKI_A: R719.2, U704.3 (+INA)
/Canali12-13/PKI_B: R739.2, U704.5 (+INB)
/Canali12-13/PKO_A: D710.2 (A), U704.1 (OUTA)
/Canali12-13/PKO_B: D730.2 (A), U704.7 (OUTB)
/Canali12-13/SD_A: C714.2, R714.1
/Canali12-13/SD_B: C734.2, R734.1
/Canali12-13/SHO_A: C715.2, R715.2, R716.1, R719.1, U701.8 (OUTC)
/Canali12-13/SHO_B: C735.2, R735.2, R736.1, R739.1, U701.14 (OUTD)
/Canali12-13/SUM_A: C715.1, R714.2, R715.1, U701.9 (-INC)
/Canali12-13/SUM_B: C735.1, R734.2, R735.1, U701.13 (-IND)
/Canali12-13/VTH_A: R717.2, R718.1, U702.2 (-INA)
/Canali12-13/VTH_B: R737.2, R738.1, U702.4 (-INB)
/Canali14-15/CMP_A: U802.7 (OUTA), U803.3 (1CLK)
/Canali14-15/CMP_B: U802.6 (OUTB), U803.11 (2CLK)
/Canali14-15/CP_A: R816.2, U802.1 (+INA)
/Canali14-15/CP_B: R836.2, U802.3 (+INB)
/Canali14-15/CSA_A: C812.1, C813.2, D801.A, R812.1, U801.2 (-INA); also elsewhere on the board
/Canali14-15/CSA_B: C832.1, C833.2, D802.A, R832.1, U801.6 (-INB); also elsewhere on the board
/Canali14-15/CSO_A: C812.2, C814.1, R812.2, U801.1 (OUTA); also elsewhere on the board
/Canali14-15/CSO_B: C832.2, C834.1, R832.2, U801.7 (OUTB); also elsewhere on the board
/Canali14-15/DK_A: C810.1, D801.K, R810.2
/Canali14-15/DK_B: C830.1, D802.K, R830.2
/Canali14-15/PKI_A: R819.2, U804.3 (+INA)
/Canali14-15/PKI_B: R839.2, U804.5 (+INB)
/Canali14-15/PKO_A: D810.2 (A), U804.1 (OUTA)
/Canali14-15/PKO_B: D830.2 (A), U804.7 (OUTB)
/Canali14-15/SD_A: C814.2, R814.1
/Canali14-15/SD_B: C834.2, R834.1
/Canali14-15/SHO_A: C815.2, R815.2, R816.1, R819.1, U801.8 (OUTC)
/Canali14-15/SHO_B: C835.2, R835.2, R836.1, R839.1, U801.14 (OUTD)
/Canali14-15/SUM_A: C815.1, R814.2, R815.1, U801.9 (-INC)
/Canali14-15/SUM_B: C835.1, R834.2, R835.1, U801.13 (-IND)
/Canali14-15/VTH_A: R817.2, R818.1, U802.2 (-INA)
/Canali14-15/VTH_B: R837.2, R838.1, U802.4 (-INB)
CS_Y3: U103.1 (~1CLR), U103.13 (~2CLR), U203.1 (~1CLR), U203.13 (~2CLR), U303.1 (~1CLR), U303.13 (~2CLR), U403.1 (~1CLR), U403.13 (~2CLR), U503.1 (~1CLR), U503.13 (~2CLR), U603.1 (~1CLR), U603.13 (~2CLR), U703.1 (~1CLR), U703.13 (~2CLR), U803.1 (~1CLR), U803.13 (~2CLR); also elsewhere on the board
GND: C110.2, C116.2, C130.2, C136.2, C150.2, C151.2, C152.2, C153.2, C154.2, C210.2, C216.2, C230.2, C236.2, C250.2, C251.2, C252.2, C253.2, C254.2, C310.2, C316.2, C330.2, C336.2, C350.2, C351.2, C352.2, C353.2, C354.2, C410.2, C416.2, C430.2, C436.2, C450.2, C451.2, C452.2, C453.2, C454.2, C510.2, C516.2, C530.2, C536.2, C550.2, C551.2, C552.2, C553.2, C554.2, C610.2, C616.2, C630.2, C636.2, C650.2, C651.2, C652.2, C653.2, C654.2, C710.2, C716.2, C730.2, C736.2, C750.2, C751.2, C752.2, C753.2, C754.2, C810.2, C816.2, C830.2, C836.2, C850.2, C851.2, C852.2, C853.2, C854.2, Q110.2 (S), Q130.2 (S), Q210.2 (S), Q230.2 (S), Q310.2 (S), Q330.2 (S), Q410.2 (S), Q430.2 (S), Q510.2 (S), Q530.2 (S), Q610.2 (S), Q630.2 (S), Q710.2 (S), Q730.2 (S), Q810.2 (S), Q830.2 (S), R118.2, R138.2, R218.2, R238.2, R318.2, R338.2, R418.2, R438.2, R518.2, R538.2, R618.2, R638.2, R718.2, R738.2, R818.2, R838.2, U101.11 (V-), U102.5 (V-), U103.7 (GND), U104.4 (V-), U201.11 (V-), U202.5 (V-), U203.7 (GND), U204.4 (V-), U301.11 (V-), U302.5 (V-), U303.7 (GND), U304.4 (V-), U401.11 (V-), U402.5 (V-), U403.7 (GND), U404.4 (V-), U501.11 (V-), U502.5 (V-), U503.7 (GND), U504.4 (V-), U601.11 (V-), U602.5 (V-), U603.7 (GND), U604.4 (V-), U701.11 (V-), U702.5 (V-), U703.7 (GND), U704.4 (V-), U801.11 (V-), U802.5 (V-), U803.7 (GND), U804.4 (V-); also elsewhere on the board
HOLD0: C116.1, D110.1 (K), Q110.3 (D), U104.2 (-INA); also elsewhere on the board
HOLD1: C136.1, D130.1 (K), Q130.3 (D), U104.6 (-INB); also elsewhere on the board
HOLD2: C216.1, D210.1 (K), Q210.3 (D), U204.2 (-INA); also elsewhere on the board
HOLD3: C236.1, D230.1 (K), Q230.3 (D), U204.6 (-INB); also elsewhere on the board
HOLD4: C316.1, D310.1 (K), Q310.3 (D), U304.2 (-INA); also elsewhere on the board
HOLD5: C336.1, D330.1 (K), Q330.3 (D), U304.6 (-INB); also elsewhere on the board
HOLD6: C416.1, D410.1 (K), Q410.3 (D), U404.2 (-INA); also elsewhere on the board
HOLD7: C436.1, D430.1 (K), Q430.3 (D), U404.6 (-INB); also elsewhere on the board
HOLD8: C516.1, D510.1 (K), Q510.3 (D), U504.2 (-INA); also elsewhere on the board
HOLD9: C536.1, D530.1 (K), Q530.3 (D), U504.6 (-INB); also elsewhere on the board
HOLD10: C616.1, D610.1 (K), Q610.3 (D), U604.2 (-INA); also elsewhere on the board
HOLD11: C636.1, D630.1 (K), Q630.3 (D), U604.6 (-INB); also elsewhere on the board
HOLD12: C716.1, D710.1 (K), Q710.3 (D), U704.2 (-INA); also elsewhere on the board
HOLD13: C736.1, D730.1 (K), Q730.3 (D), U704.6 (-INB); also elsewhere on the board
HOLD14: C816.1, D810.1 (K), Q810.3 (D), U804.2 (-INA); also elsewhere on the board
HOLD15: C836.1, D830.1 (K), Q830.3 (D), U804.6 (-INB); also elsewhere on the board
PK_RST: Q110.1 (G), Q130.1 (G), Q210.1 (G), Q230.1 (G), Q310.1 (G), Q330.1 (G), Q410.1 (G), Q430.1 (G), Q510.1 (G), Q530.1 (G), Q610.1 (G), Q630.1 (G), Q710.1 (G), Q730.1 (G), Q810.1 (G), Q830.1 (G); also elsewhere on the board
Q0: U103.5 (1Q); also elsewhere on the board
Q1: U103.9 (2Q); also elsewhere on the board
Q2: U203.5 (1Q); also elsewhere on the board
Q3: U203.9 (2Q); also elsewhere on the board
Q4: U303.5 (1Q); also elsewhere on the board
Q5: U303.9 (2Q); also elsewhere on the board
Q6: U403.5 (1Q); also elsewhere on the board
Q7: U403.9 (2Q); also elsewhere on the board
Q8: U503.5 (1Q); also elsewhere on the board
Q9: U503.9 (2Q); also elsewhere on the board
Q10: U603.5 (1Q); also elsewhere on the board
Q11: U603.9 (2Q); also elsewhere on the board
Q12: U703.5 (1Q); also elsewhere on the board
Q13: U703.9 (2Q); also elsewhere on the board
Q14: U803.5 (1Q); also elsewhere on the board
Q15: U803.9 (2Q); also elsewhere on the board
QN0: U103.6 (~1Q); also elsewhere on the board
QN1: U103.8 (~2Q); also elsewhere on the board
QN2: U203.6 (~1Q); also elsewhere on the board
QN3: U203.8 (~2Q); also elsewhere on the board
QN4: U303.6 (~1Q); also elsewhere on the board
QN5: U303.8 (~2Q); also elsewhere on the board
QN6: U403.6 (~1Q); also elsewhere on the board
QN7: U403.8 (~2Q); also elsewhere on the board
QN8: U503.6 (~1Q); also elsewhere on the board
QN9: U503.8 (~2Q); also elsewhere on the board
QN10: U603.6 (~1Q); also elsewhere on the board
QN11: U603.8 (~2Q); also elsewhere on the board
QN12: U703.6 (~1Q); also elsewhere on the board
QN13: U703.8 (~2Q); also elsewhere on the board
QN14: U803.6 (~1Q); also elsewhere on the board
QN15: U803.8 (~2Q); also elsewhere on the board
TEST_INJ: C113.1, C133.1, C213.1, C233.1, C313.1, C333.1, C413.1, C433.1, C513.1, C533.1, C613.1, C633.1, C713.1, C733.1, C813.1, C833.1; also elsewhere on the board
VBIAS_SH: R110.1, R130.1, R210.1, R230.1, R310.1, R330.1, R410.1, R430.1, R510.1, R530.1, R610.1, R630.1, R710.1, R730.1, R810.1, R830.1; also elsewhere on the board
VTH: R117.1, R137.1, R217.1, R237.1, R317.1, R337.1, R417.1, R437.1, R517.1, R537.1, R617.1, R637.1, R717.1, R737.1, R817.1, R837.1; also elsewhere on the board

Notes on the sheet:
DUE CANALI (A, B) - foglio ripetuto 8 volte: canali 2k e 2k+1. Valori di retroazione da variabili di progetto: Rf = ${RF}, Cf = ${CF} (File > Impostazioni progetto > Variabili di testo).
Catena: VBPW34S -> CSA (OPA4140 A/B, +IN a 1V25_REF) -> shaper CR-RC invertente x50 tau 1 us (OPA4140 C/D) -> TLV3502 (soglia VTH) -> 74LVC74A (latch, CLR con CS_Y3) -> rilevatore di picco OPA2365 + BAS416 + 1 nF C0G.
Iniezione di carica di test: 0.5 pF da TEST_INJ (gradino di ~3.3 mV -> ~1.6 fC). Rf2/Cf2 DNP in parallelo per prove. Trim di soglia per canale DNP (R tra VTH_x e GND).

Board: 4 copper layers, 490 parts (16 on the bottom side), 297 nets, no tracks yet.

Other parts of the board:
C111, C131, C211, C231, C311, C331, C411, C431, C511, C531, C611, C631, C711, C731, C811, C831: 1p C0G; C_0402_1005Metric
H1, H2, H3, H4: MountingHole_3.2mm_M3
R111, R131, R211, R231, R311, R331, R411, R431, R511, R531, R611, R631, R711, R731, R811, R831: 100M; R_0805_2012Metric

Their connections:
/Canali00-01/CSA_A: C111.1, R111.1; also elsewhere on the board
/Canali00-01/CSA_B: C131.1, R131.1; also elsewhere on the board
/Canali00-01/CSO_A: C111.2, R111.2; also elsewhere on the board
/Canali00-01/CSO_B: C131.2, R131.2; also elsewhere on the board
/Canali02-03/CSA_A: C211.1, R211.1; also elsewhere on the board
/Canali02-03/CSA_B: C231.1, R231.1; also elsewhere on the board
/Canali02-03/CSO_A: C211.2, R211.2; also elsewhere on the board
/Canali02-03/CSO_B: C231.2, R231.2; also elsewhere on the board
/Canali04-05/CSA_A: C311.1, R311.1; also elsewhere on the board
/Canali04-05/CSA_B: C331.1, R331.1; also elsewhere on the board
/Canali04-05/CSO_A: C311.2, R311.2; also elsewhere on the board
/Canali04-05/CSO_B: C331.2, R331.2; also elsewhere on the board
/Canali06-07/CSA_A: C411.1, R411.1; also elsewhere on the board
/Canali06-07/CSA_B: C431.1, R431.1; also elsewhere on the board
/Canali06-07/CSO_A: C411.2, R411.2; also elsewhere on the board
/Canali06-07/CSO_B: C431.2, R431.2; also elsewhere on the board
/Canali08-09/CSA_A: C511.1, R511.1; also elsewhere on the board
/Canali08-09/CSA_B: C531.1, R531.1; also elsewhere on the board
/Canali08-09/CSO_A: C511.2, R511.2; also elsewhere on the board
/Canali08-09/CSO_B: C531.2, R531.2; also elsewhere on the board
/Canali10-11/CSA_A: C611.1, R611.1; also elsewhere on the board
/Canali10-11/CSA_B: C631.1, R631.1; also elsewhere on the board
/Canali10-11/CSO_A: C611.2, R611.2; also elsewhere on the board
/Canali10-11/CSO_B: C631.2, R631.2; also elsewhere on the board
/Canali12-13/CSA_A: C711.1, R711.1; also elsewhere on the board
/Canali12-13/CSA_B: C731.1, R731.1; also elsewhere on the board
/Canali12-13/CSO_A: C711.2, R711.2; also elsewhere on the board
/Canali12-13/CSO_B: C731.2, R731.2; also elsewhere on the board
/Canali14-15/CSA_A: C811.1, R811.1; also elsewhere on the board
/Canali14-15/CSA_B: C831.1, R831.1; also elsewhere on the board
/Canali14-15/CSO_A: C811.2, R811.2; also elsewhere on the board
/Canali14-15/CSO_B: C831.2, R831.2; also elsewhere on the board

## KiCad design PianoTest/PianoTest.kicad_pcb

File PianoTest/README.md:

# PianoTest

Piano di test MuonScope per il bus **MIKILAB REV5.1**. Serve a trovare sperimentalmente i valori migliori della rete di retroazione (Rf/Cf), della formatura e del bias per il fotodiodo, prima di progettare la matrice dei sensori.

Progetto KiCad 10: `PianoTest.kicad_pro`. Simboli locali in `PianoTest.kicad_sym`. Schema esportato in `PianoTest-schema.pdf`.

## Fogli

| Foglio | Contenuto |
|---|---|
| Rivelatore | Fotodiodo VBPW34S. Preamplificatore di carica OPA4172 A (Cf 1 pF, Rf 100M di default). Shaper CR-RC τ ≈ 1 µs: C invertente ×10, D non invertente ×5 (totale ×50). Base 1V25 bufferizzata da B. Comparatore TLV3501 su SHAPER_OUT con soglia VTH dal DAC (OUTB), evento memorizzato nel latch 74LVC1G74 (HIT_LATCH). Rilevatore di picco OPA2365 + BAS416 + hold 1 nF C0G prima dell'ADS8326 (R135; R136 DNP lo scavalca). ADS8326 con filtro 47 Ω + 1 nF. TMP117. SMA e test point su CSA_OUT e SHAPER_OUT. Opzione JFET BF862 in cascode, non montata, con jumper 0R. |
| RetroactionNetwork | MCP23S17. Rf da 10k a 10M su 2× TMUX1112 (pull-down: aperti al reset). Cf da 0.5 a 100 pF su 2× BGSA142: −IN → Cf → RFx → RFC → 10 nF C0G → uscita, con 100M verso GND su ogni porta. CTL con partitore 10k/22k. |
| EmettitoreTest | LTC6993-2 con AD5245 (I2C, 0x2C) + 47k sul SET. BSS138 → LED IR alimentato da +5V. TRIG dallo strobe CS_Y4 (accesso SPI all'indirizzo 4) o da J301. |
| BiasDiodo | DAC61402 alimentato da VHV_36V (RC 100 Ω + 2×1 µF/100 V). OUTA → shunt 10k (INA239) → RC 1k/100 nF vicino al diodo. OUTB (range 0–5 V) con partitore 22k/10k e BAT54S fa da soglia VTH del comparatore. |
| bus-pnp | J_IN/J_OUT FPC 28 pin. 74HC283 (ID+1), 74HC85 (PREFIX = ID), 74HC138 (Y0 ADC, Y1 DAC, Y2 INA, Y3–Y5 TP, Y6 EEPROM 25AA02E48, Y7 MCP). Buffer 2G17 su SCLK/MOSI, 1G125 su MISO, 1G07 su ALERT#. ESD TPD1E10B06. |

## Bus

- Tutti i segnali passano da J_IN a J_OUT, tranne ID[0..2] (pin 25–27), che esce come ID+1.
- Pin 8/9 (ex V_BIAS_1/2) portano **VHV_36V** dal modulo Power.
- I2C (pin 14/15): AD5245 0x2C, TMP117 0x48. Le pull-up sono sulla scheda master.
- MCP23S17: configurare MIRROR=1 (INTA riassume entrambe le porte). Indirizzo hardware 000 (il CS è già decodificato per piano).
- Guasti (FAULT del DAC, ALERT di INA239 e TMP117) in wired-OR su PL_FAULT → GPA6 dell'MCP → ALERT#.
- Evento: HIT_LATCH → GPA7 dell'MCP → ALERT#. Sequenza del master: legge l'MCP, converte con l'ADS8326 (Y0) il valore di picco, poi fa un accesso all'indirizzo 3 (CS_Y3) che azzera il picco e il latch. Indirizzo 4 (CS_Y4): impulso del LED di test.
- REV5.1: pin 28 = HIT# (coincidenze). HIT del comparatore → monostabile 74LVC1G123 (2k + 27 pF, circa 170–200 ns) → 74LVC1G06 open-drain su HIT#, passante J_IN → J_OUT. HIT anche su TP104 e SMA J103.

## Stato (2026-10-14)

- Schema: **ERC 0 violazioni**.
- PCB: 4 strati (F.Cu segnali, In1 GND, In2 PWR, B.Cu segnali), 120 × 90 mm. J_IN sul lato sinistro, J_OUT sul destro. Componenti piazzati a gruppi per foglio, **non sbrogliato**.
- DRC: 483 violazioni + 499 non connessi, attesi senza sbroglio. Sono soprattutto serigrafie sovrapposte, clearance interne ai footprint MIKILAB a passo fine e courtyard malformati di quei footprint.
- FPC J401/J402: XUNPU FPC-05F-28PH20 (LCSC C2856807), footprint e modello 3D importati da EasyEDA in `PianoTest.pretty` e `PianoTest.3dshapes` (pad 0.30 × 1.25 mm, passo 0.5 mm, pin 1–28 su 13.5 mm, ancoraggi 2.0 × 2.5 mm a ±8.44 mm).

## Punti aperti

- BGSA142: datasheet Infineon non scaricabile. VDD 1.65–3.6 V (alimentato a 3.3 V). VIH dei CTL e combinabilità delle porte da verificare: il partitore 10k/22k porta i CTL a 2.27 V.
- Rf 100M (0805 alta resistenza) e Cf piccoli: tenere pulita l'area attorno a CSA_IN (guard ring, niente solder mask, lavaggio).
- Bias: C101, C103 e C506 sono C0G 100 nF 100 V 1206 (TDK C3216C0G2A104J160AE), perché gli X7R perderebbero nA a 30 V.
- Opzione JFET: valori di polarizzazione (R124–R129) da tarare sul BF862 montato.
- FPC: quote del footprint EasyEDA da confrontare con il disegno XUNPU (il PDF LCSC non si scarica in automatico). Connettore con contatti in basso: verificare il verso del cavo.
- Piano di alimentazione In2: oggi è una sola zona +3V3, da dividere con +5V in fase di sbroglio.

Footprint `MIKILAB_*` dalla libreria esterna MIKILAB (variabile `${MIKILAB}`), non inclusa nel repository.

Schematic: PianoTest.kicad_sch

Notes on the sheet:
PianoTest - piano di test MuonScope sul bus MIKILAB (REV5.0). Vedi README.md.

Schematic: rivelatore.kicad_sch

Parts:
C101, C103: 100nF/100V C0G; C_1206_3216Metric; MPN C3216C0G2A104J160AE
C102, C106, C107, C108: 1nF C0G; C_0603_1608Metric
C105: 100pF C0G; C_0603_1608Metric
C111: 47uF; C_1206_3216Metric
C112, C114: 1uF; C_0603_1608Metric
C113, C115, C116, C117, C118, C119, C120: 100nF; C_0603_1608Metric
C124: 10uF; C_0805_2012Metric; not fitted
C127, C129: 1uF; C_0603_1608Metric; not fitted
D101: VBPW34S; XDCR_VBPW34S; MPN VBPW34S
D102, D103: BAS416; D_SOD-323; MPN BAS416
J101: SMA preampl.; SMA_Amphenol_132134_Vertical
J102: SMA shaper; SMA_Amphenol_132134_Vertical
J103: SMA HIT; SMA_Amphenol_132134_Vertical
Q101, Q102: BF862; SOT-23; MPN BF862; not fitted
Q103: BSS138; SOT-23
R101, R103, R105, R112, R130, R132: 1k; R_0603_1608Metric
R102: 1M; R_0603_1608Metric
R104, R133: 10k; R_0603_1608Metric
R106: 47R; R_0603_1608Metric
R107, R108, R137: 100R; R_0603_1608Metric
R113: 4.02k; R_0603_1608Metric
R120, R121, R135: 0R; R_0603_1608Metric
R122, R123, R136: 0R; R_0603_1608Metric; not fitted
R124: 750R; R_0603_1608Metric; not fitted
R125: 1k; R_0603_1608Metric; not fitted
R126, R128: 10k; R_0603_1608Metric; not fitted
R127: 4.3k; R_0603_1608Metric; not fitted
R129: 15k; R_0603_1608Metric; not fitted
R131: 1M; R_0603_1608Metric; not fitted
R134: 100k; R_0603_1608Metric
TP101: CSA_OUT; TestPoint_Pad_D1.0mm
TP102: SHAPER_OUT; TestPoint_Pad_D1.0mm
TP103: VBIAS_DIODE; TestPoint_Pad_D1.0mm
TP104: HIT; TestPoint_Pad_D1.0mm
TP105: PK_OUT; TestPoint_Pad_D1.0mm
U101: OPA4172ID; SOIC127P600X175-14N; MPN OPA4172ID
U102: ADS8326IDGKT; SOP65P490X110-8N; MPN ADS8326IDGKT
U103: TMP117AIDRVR; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TMP117AIDRVR
U104: TLV3501AIDBVR; SOT-23-6; MPN TLV3501AIDBVR (LCSC C193413)
U105: SN74LVC1G74DCUR; VSSOP-8_2.3x2mm_P0.5mm; MPN SN74LVC1G74DCUR
U106: OPA2365AIDR; SOIC-8_3.9x4.9mm_P1.27mm; MPN OPA2365AIDR
U107: SN74LVC1G04DBVR; SOT-23-5; MPN SN74LVC1G04DBVR

Connections:
1V25_REF: R121.1, U101.5 (+INB); also elsewhere on the board
2V5_REF: C111.1, U102.1 (REF); also elsewhere on the board
+3V3: C114.1, C115.1, C116.1, C118.1, C119.1, C120.1, U102.8 (VDD), U103.5 (V+), U104.4 (V+), U105.2 (D), U105.7 (~PRE), U105.8 (VCC), U106.8 (V+), U107.5 (VCC); also elsewhere on the board
+5V: C112.1, C113.1, R125.1, R126.1, R128.1, U101.4 (V+); also elsewhere on the board
/Rivelatore/ADC_IN: C107.1, R106.2, U102.2 (+IN)
/Rivelatore/ADC_SRC: R106.1, R135.2, R136.2
/Rivelatore/CASC_B: C127.1, Q102.3 (G), R126.2, R127.1
/Rivelatore/CMP_P: R130.2, R131.2, U104.3 (+IN)
/Rivelatore/DIODE_K: C103.1, D101.K, R102.2
/Rivelatore/JFET_C: Q101.1 (D), Q102.2 (S)
/Rivelatore/JFET_D: Q102.1 (D), R122.1, R125.2
/Rivelatore/JFET_REF: C129.1, R123.1, R128.2, R129.1
/Rivelatore/JFET_S: C124.1, Q101.2 (S), R124.1
/Rivelatore/OPA_NEG: R120.2, R123.2, U101.2 (-INA)
/Rivelatore/OPA_POS: R121.2, R122.2, U101.3 (+INA)
/Rivelatore/PK_A: D102.2 (A), D103.1 (K), U106.1 (OUTA)
/Rivelatore/PK_FB: D103.2 (A), R133.2, U106.2 (-INA)
/Rivelatore/PK_HOLD: C108.1, D102.1 (K), Q103.3 (D), U106.5 (+INB)
/Rivelatore/PK_IN: R132.2, U106.3 (+INA)
/Rivelatore/PK_OUT: R133.1, R135.1, TP105.1, U106.6 (-INB), U106.7 (OUTB)
/Rivelatore/PK_RST: Q103.1 (G), R134.1, U107.4 (Y)
/Rivelatore/SHAPER_OUT: R108.1, R113.2, R130.1, R132.1, R136.1, TP102.1, U101.14 (OUTD)
/Rivelatore/SH_BASE: C106.2, C117.1, R112.2, U101.6 (-INB), U101.7 (OUTB), U101.10 (+INC)
/Rivelatore/SH_C: C105.2, R104.2, R105.1, U101.8 (OUTC)
/Rivelatore/SH_CD: C102.2, R103.1
/Rivelatore/SH_FB: R112.1, R113.1, U101.13 (-IND)
/Rivelatore/SH_RC: C106.1, R105.2, U101.12 (+IND)
/Rivelatore/SH_SUM: C105.1, R103.2, R104.1, U101.9 (-INC)
/Rivelatore/SMA_HIT: J103.1 (In), R137.2
/Rivelatore/SMA_PRE: J101.1 (In), R107.2
/Rivelatore/SMA_SH: J102.1 (In), R108.2
/Rivelatore/VBIAS_DIODE: C101.1, R101.2, R102.1, TP103.1
CSA_IN: D101.A, Q101.3 (G), R120.1; also elsewhere on the board
CSA_OUT: C102.1, R107.1, TP101.1, U101.1 (OUTA); also elsewhere on the board
CS_ADC: U102.5 (~CS); also elsewhere on the board
CS_Y3: U105.6 (~CLR), U107.2 (A); also elsewhere on the board
GND: C101.2, C103.2, C107.2, C108.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C124.2, C127.2, C129.2, J101.2 (Ext), J102.2 (Ext), J103.2 (Ext), Q103.2 (S), R124.2, R127.2, R129.2, R134.2, U101.11 (V-), U102.3 (-IN), U102.4 (GND), U103.2 (GND), U103.4 (ADD0), U103.7 (EP), U104.2 (V-), U104.6 (SHDN), U105.4 (GND), U106.4 (V-), U107.3 (GND); also elsewhere on the board
HIT: R131.1, R137.1, TP104.1, U104.5 (OUT), U105.1 (CLK); also elsewhere on the board
HIT_LATCH: U105.5 (Q); also elsewhere on the board
I2C_SCL: U103.1 (SCL); also elsewhere on the board
I2C_SDA: U103.6 (SDA); also elsewhere on the board
MISO_L: U102.6 (DOUT); also elsewhere on the board
PL_FAULT: U103.3 (ALERT); also elsewhere on the board
SCLK_L: U102.7 (DCLOCK); also elsewhere on the board
VBIAS_SH: R101.1; also elsewhere on the board
VTH: U104.1 (-IN); also elsewhere on the board

Notes on the sheet:
PREAMPLIFICATORE DI CARICA (OPA4172 A, Cf 1 pF + Rf 100M di default) -> shaper CR-RC tau 1 us: C invertente x10 (CR), D non invertente x5 (RC) = x50. Base 1V25 bufferizzata da B.
BPW34 a 30-36 V: Cd ~8-9 pF, MIP ~1-1.3 fC -> ~1 mV su CSA_OUT (negativo), ~50 mV positivi su SHAPER_OUT sopra 1.25 V. Filtro ADC 47R + 1 nF.
OPZIONE JFET (DNP): BF862 a source comune + BF862 cascode. Diretto = R120/R121 montate; JFET = togliere R120/R121, montare R122/R123, Q101/Q102 e la polarizzazione (valori da tarare).
COMPARATORE E PICCO: TLV3501 (isteresi interna 6 mV) confronta SHAPER_OUT con VTH (DAC OUTB, partitore). HIT memorizzato da U105 -> HIT_LATCH -> MCP GPA7 -> ALERT#.
Rilevatore di picco U106 (OPA2365 a 3V3, BAS416, hold 1 nF C0G) tra shaper e ADC. Reset di picco e latch: accesso SPI all'indirizzo 3 del piano (CS_Y3 basso). R135 diretto / R136 (DNP) scavalca il picco.
SMA con 100R in serie: oscilloscopio a 1 MOhm. C101/C103/C506 C0G 100 nF 100 V 1206 (TDK C3216C0G2A104J160AE): niente X7R, perdono nA a 30 V.
